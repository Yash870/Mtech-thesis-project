+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_679 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_681 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_59 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_703 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_705 PDIFF_701 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_6 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_23 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_60 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW61 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_23 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_61 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW62 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_43 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_62 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW63 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_43 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_63 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_703 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_705 PDIFF_707 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_7 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_709 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_711 PDIFF_707 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_8 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW9 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_709 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_711 PDIFF_599 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_9 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XI66 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13
+  BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25
+  BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37
+  BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49
+  BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61
+  BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73
+  BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85
+  BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97
+  BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108
+  BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127 BL_128 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12
+  BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22
+  BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42
+  BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50 BL__51 BL__52
+  BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60 BL__61 BL__62
+  BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BL__72
+  BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80 BL__81 BL__82
+  BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92
+  BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100 BL__101 BL__102
+  BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109 BL__110 BL__111
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BL__119 BL__120
+  BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL DIFF_591
+  DIFF1_0_589 DIFF1_1_587 DIFF1_2_585 DIFF1_3_583 DIFF1_4_581 DIFF1_5_579
+  DIFF1_6_577 DIFF1_7_575 DIFF1_8_573 DIFF1_9_571 DIFF1_10_569 DIFF1_11_567
+  DIFF1_12_565 DIFF1_13_563 DIFF1_14_561 DIFF1_15_559 DIFF1_16_557
+  DIFF1_17_555 DIFF1_18_553 DIFF1_19_551 DIFF1_20_549 DIFF1_21_547
+  DIFF1_22_545 DIFF1_23_543 DIFF1_24_541 DIFF1_25_539 DIFF1_26_537
+  DIFF1_27_535 DIFF1_28_533 DIFF1_29_531 DIFF1_30_529 DIFF1_31_527
+  DIFF1_32_525 DIFF1_33_523 DIFF1_34_521 DIFF1_35_519 DIFF1_36_517
+  DIFF1_37_515 DIFF1_38_513 DIFF1_39_511 DIFF1_40_509 DIFF1_41_507
+  DIFF1_42_505 DIFF1_43_503 DIFF1_44_501 DIFF1_45_499 DIFF1_46_497
+  DIFF1_47_495 DIFF1_48_493 DIFF1_49_491 DIFF1_50_489 DIFF1_51_487
+  DIFF1_52_485 DIFF1_53_483 DIFF1_54_481 DIFF1_55_479 DIFF1_56_477
+  DIFF1_57_475 DIFF1_58_473 DIFF1_59_471 DIFF1_60_469 DIFF1_61_467
+  DIFF1_62_465 DIFF1_63_463 DIFF1_64_461 DIFF1_65_459 DIFF1_66_457
+  DIFF1_67_455 DIFF1_68_453 DIFF1_69_451 DIFF1_70_449 DIFF1_71_447
+  DIFF1_72_445 DIFF1_73_443 DIFF1_74_441 DIFF1_75_439 DIFF1_76_437
+  DIFF1_77_435 DIFF1_78_433 DIFF1_79_431 DIFF1_80_429 DIFF1_81_427
+  DIFF1_82_425 DIFF1_83_423 DIFF1_84_421 DIFF1_85_419 DIFF1_86_417
+  DIFF1_87_415 DIFF1_88_413 DIFF1_89_411 DIFF1_90_409 DIFF1_91_407
+  DIFF1_92_405 DIFF1_93_403 DIFF1_94_401 DIFF1_95_399 DIFF1_96_397
+  DIFF1_97_395 DIFF1_98_393 DIFF1_99_391 DIFF1_100_389 DIFF1_101_387
+  DIFF1_102_385 DIFF1_103_383 DIFF1_104_381 DIFF1_105_379 DIFF1_106_377
+  DIFF1_107_375 DIFF1_108_373 DIFF1_109_371 DIFF1_110_369 DIFF1_111_367
+  DIFF1_112_365 DIFF1_113_363 DIFF1_114_361 DIFF1_115_359 DIFF1_116_357
+  DIFF1_117_355 DIFF1_118_353 DIFF1_119_351 DIFF1_120_349 DIFF1_121_347
+  DIFF1_122_345 DIFF1_123_343 DIFF1_124_341 DIFF1_125_339 DIFF1_126_337
+  DIFF1_127_335 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89
+  GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99
+  GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108
+  GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117
+  GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126
+  GDL_127 GDL_128 NDIFF_593 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46
+  PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56
+  PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66
+  PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76
+  PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86
+  PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96
+  PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105
+  PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114
+  PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123
+  PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_64 VSSE VDDPE
+  VDDCE lut_sram_1024x16CAPBK_ROW128RE
XMWLROWBOT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_201 DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7
+  DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13 DIFF1_14 DIFF1_15
+  DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21 DIFF1_22 DIFF1_23
+  DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29 DIFF1_30 DIFF1_31
+  DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37 DIFF1_38 DIFF1_39
+  DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44 DIFF1_45 DIFF1_46 DIFF1_47
+  DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52 DIFF1_53 DIFF1_54 DIFF1_55
+  DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60 DIFF1_61 DIFF1_62 DIFF1_63
+  DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68 DIFF1_69 DIFF1_70 DIFF1_71
+  DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76 DIFF1_77 DIFF1_78 DIFF1_79
+  DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84 DIFF1_85 DIFF1_86 DIFF1_87
+  DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92 DIFF1_93 DIFF1_94 DIFF1_95
+  DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100 DIFF1_101 DIFF1_102 DIFF1_103
+  DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107 DIFF1_108 DIFF1_109 DIFF1_110
+  DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114 DIFF1_115 DIFF1_116 DIFF1_117
+  DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121 DIFF1_122 DIFF1_123 DIFF1_124
+  DIFF1_125 DIFF1_126 DIFF1_127 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4
+  DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13
+  DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21
+  DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29
+  DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37
+  DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42 DIFF2_43 DIFF2_44 DIFF2_45
+  DIFF2_46 DIFF2_47 DIFF2_48 DIFF2_49 DIFF2_50 DIFF2_51 DIFF2_52 DIFF2_53
+  DIFF2_54 DIFF2_55 DIFF2_56 DIFF2_57 DIFF2_58 DIFF2_59 DIFF2_60 DIFF2_61
+  DIFF2_62 DIFF2_63 DIFF2_64 DIFF2_65 DIFF2_66 DIFF2_67 DIFF2_68 DIFF2_69
+  DIFF2_70 DIFF2_71 DIFF2_72 DIFF2_73 DIFF2_74 DIFF2_75 DIFF2_76 DIFF2_77
+  DIFF2_78 DIFF2_79 DIFF2_80 DIFF2_81 DIFF2_82 DIFF2_83 DIFF2_84 DIFF2_85
+  DIFF2_86 DIFF2_87 DIFF2_88 DIFF2_89 DIFF2_90 DIFF2_91 DIFF2_92 DIFF2_93
+  DIFF2_94 DIFF2_95 DIFF2_96 DIFF2_97 DIFF2_98 DIFF2_99 DIFF2_100 DIFF2_101
+  DIFF2_102 DIFF2_103 DIFF2_104 DIFF2_105 DIFF2_106 DIFF2_107 DIFF2_108
+  DIFF2_109 DIFF2_110 DIFF2_111 DIFF2_112 DIFF2_113 DIFF2_114 DIFF2_115
+  DIFF2_116 DIFF2_117 DIFF2_118 DIFF2_119 DIFF2_120 DIFF2_121 DIFF2_122
+  DIFF2_123 DIFF2_124 DIFF2_125 DIFF2_126 DIFF2_127 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44
+  GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54
+  GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64
+  GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74
+  GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84
+  GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94
+  GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104
+  GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113
+  GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122
+  GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF_203 PDIFF_333 PG0_0
+  PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12
+  PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22
+  PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32
+  PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92
+  PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102
+  PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111
+  PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120
+  PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1
+  TL1 WL_65 VSSE VDDPE VDDCE lut_sram_1024x16MWL_ROW128RO
XMWLROWTOP BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_591 DIFF1_0_589 DIFF1_1_587 DIFF1_2_585 DIFF1_3_583 DIFF1_4_581
+  DIFF1_5_579 DIFF1_6_577 DIFF1_7_575 DIFF1_8_573 DIFF1_9_571 DIFF1_10_569
+  DIFF1_11_567 DIFF1_12_565 DIFF1_13_563 DIFF1_14_561 DIFF1_15_559
+  DIFF1_16_557 DIFF1_17_555 DIFF1_18_553 DIFF1_19_551 DIFF1_20_549
+  DIFF1_21_547 DIFF1_22_545 DIFF1_23_543 DIFF1_24_541 DIFF1_25_539
+  DIFF1_26_537 DIFF1_27_535 DIFF1_28_533 DIFF1_29_531 DIFF1_30_529
+  DIFF1_31_527 DIFF1_32_525 DIFF1_33_523 DIFF1_34_521 DIFF1_35_519
+  DIFF1_36_517 DIFF1_37_515 DIFF1_38_513 DIFF1_39_511 DIFF1_40_509
+  DIFF1_41_507 DIFF1_42_505 DIFF1_43_503 DIFF1_44_501 DIFF1_45_499
+  DIFF1_46_497 DIFF1_47_495 DIFF1_48_493 DIFF1_49_491 DIFF1_50_489
+  DIFF1_51_487 DIFF1_52_485 DIFF1_53_483 DIFF1_54_481 DIFF1_55_479
+  DIFF1_56_477 DIFF1_57_475 DIFF1_58_473 DIFF1_59_471 DIFF1_60_469
+  DIFF1_61_467 DIFF1_62_465 DIFF1_63_463 DIFF1_64_461 DIFF1_65_459
+  DIFF1_66_457 DIFF1_67_455 DIFF1_68_453 DIFF1_69_451 DIFF1_70_449
+  DIFF1_71_447 DIFF1_72_445 DIFF1_73_443 DIFF1_74_441 DIFF1_75_439
+  DIFF1_76_437 DIFF1_77_435 DIFF1_78_433 DIFF1_79_431 DIFF1_80_429
+  DIFF1_81_427 DIFF1_82_425 DIFF1_83_423 DIFF1_84_421 DIFF1_85_419
+  DIFF1_86_417 DIFF1_87_415 DIFF1_88_413 DIFF1_89_411 DIFF1_90_409
+  DIFF1_91_407 DIFF1_92_405 DIFF1_93_403 DIFF1_94_401 DIFF1_95_399
+  DIFF1_96_397 DIFF1_97_395 DIFF1_98_393 DIFF1_99_391 DIFF1_100_389
+  DIFF1_101_387 DIFF1_102_385 DIFF1_103_383 DIFF1_104_381 DIFF1_105_379
+  DIFF1_106_377 DIFF1_107_375 DIFF1_108_373 DIFF1_109_371 DIFF1_110_369
+  DIFF1_111_367 DIFF1_112_365 DIFF1_113_363 DIFF1_114_361 DIFF1_115_359
+  DIFF1_116_357 DIFF1_117_355 DIFF1_118_353 DIFF1_119_351 DIFF1_120_349
+  DIFF1_121_347 DIFF1_122_345 DIFF1_123_343 DIFF1_124_341 DIFF1_125_339
+  DIFF1_126_337 DIFF1_127_335 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5
+  DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13
+  DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21
+  DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29
+  DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37
+  DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42 DIFF2_43 DIFF2_44 DIFF2_45
+  DIFF2_46 DIFF2_47 DIFF2_48 DIFF2_49 DIFF2_50 DIFF2_51 DIFF2_52 DIFF2_53
+  DIFF2_54 DIFF2_55 DIFF2_56 DIFF2_57 DIFF2_58 DIFF2_59 DIFF2_60 DIFF2_61
+  DIFF2_62 DIFF2_63 DIFF2_64 DIFF2_65 DIFF2_66 DIFF2_67 DIFF2_68 DIFF2_69
+  DIFF2_70 DIFF2_71 DIFF2_72 DIFF2_73 DIFF2_74 DIFF2_75 DIFF2_76 DIFF2_77
+  DIFF2_78 DIFF2_79 DIFF2_80 DIFF2_81 DIFF2_82 DIFF2_83 DIFF2_84 DIFF2_85
+  DIFF2_86 DIFF2_87 DIFF2_88 DIFF2_89 DIFF2_90 DIFF2_91 DIFF2_92 DIFF2_93
+  DIFF2_94 DIFF2_95 DIFF2_96 DIFF2_97 DIFF2_98 DIFF2_99 DIFF2_100 DIFF2_101
+  DIFF2_102 DIFF2_103 DIFF2_104 DIFF2_105 DIFF2_106 DIFF2_107 DIFF2_108
+  DIFF2_109 DIFF2_110 DIFF2_111 DIFF2_112 DIFF2_113 DIFF2_114 DIFF2_115
+  DIFF2_116 DIFF2_117 DIFF2_118 DIFF2_119 DIFF2_120 DIFF2_121 DIFF2_122
+  DIFF2_123 DIFF2_124 DIFF2_125 DIFF2_126 DIFF2_127 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44
+  GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54
+  GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64
+  GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74
+  GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84
+  GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94
+  GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104
+  GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113
+  GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122
+  GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF_593 PDIFF_333 PG0_0
+  PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12
+  PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22
+  PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32
+  PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92
+  PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102
+  PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111
+  PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120
+  PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1
+  TL1 WL_65 VSSE VDDPE VDDCE lut_sram_1024x16MWL_ROW128RO
.ENDS lut_sram_1024x16CABR128X64TT
****
.SUBCKT lut_sram_1024x16BK0B16X64 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AY0TRACK AY1TRACK AY2TRACK BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL_129 BL_130 BL_131 BL_132 BL_133
+  BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142 BL_143
+  BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152 BL_153
+  BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 BL_160 BL_161 BL_162 BL_163
+  BL_164 BL_165 BL_166 BL_167 BL_168 BL_169 BL_170 BL_171 BL_172 BL_173
+  BL_174 BL_175 BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182 BL_183
+  BL_184 BL_185 BL_186 BL_187 BL_188 BL_189 BL_190 BL_191 BL_192 BL_193
+  BL_194 BL_195 BL_196 BL_197 BL_198 BL_199 BL_200 BL_201 BL_202 BL_203
+  BL_204 BL_205 BL_206 BL_207 BL_208 BL_209 BL_210 BL_211 BL_212 BL_213
+  BL_214 BL_215 BL_216 BL_217 BL_218 BL_219 BL_220 BL_221 BL_222 BL_223
+  BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230 BL_231 BL_232 BL_233
+  BL_234 BL_235 BL_236 BL_237 BL_238 BL_239 BL_240 BL_241 BL_242 BL_243
+  BL_244 BL_245 BL_246 BL_247 BL_248 BL_249 BL_250 BL_251 BL_252 BL_253
+  BL_254 BL_255 BL_256 BL_257 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 BL__128 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134
+  BL__135 BL__136 BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL__143
+  BL__144 BL__145 BL__146 BL__147 BL__148 BL__149 BL__150 BL__151 BL__152
+  BL__153 BL__154 BL__155 BL__156 BL__157 BL__158 BL__159 BL__160 BL__161
+  BL__162 BL__163 BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170
+  BL__171 BL__172 BL__173 BL__174 BL__175 BL__176 BL__177 BL__178 BL__179
+  BL__180 BL__181 BL__182 BL__183 BL__184 BL__185 BL__186 BL__187 BL__188
+  BL__189 BL__190 BL__191 BL__192 BL__193 BL__194 BL__195 BL__196 BL__197
+  BL__198 BL__199 BL__200 BL__201 BL__202 BL__203 BL__204 BL__205 BL__206
+  BL__207 BL__208 BL__209 BL__210 BL__211 BL__212 BL__213 BL__214 BL__215
+  BL__216 BL__217 BL__218 BL__219 BL__220 BL__221 BL__222 BL__223 BL__224
+  BL__225 BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233
+  BL__234 BL__235 BL__236 BL__237 BL__238 BL__239 BL__240 BL__241 BL__242
+  BL__243 BL__244 BL__245 BL__246 BL__247 BL__248 BL__249 BL__250 BL__251
+  BL__252 BL__253 BL__254 BL__255 BS0N BS1N BTP0 BTP1 BTP2 BTP3 G0_TIEHIGH
+  G1_TIEHIGH GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89
+  GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99
+  GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108
+  GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117
+  GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126
+  GDL_127 GDL_128 GDL_129 GDL_130 GDL_131 GDL_132 GDL_133 GDL_134 GDL_135
+  GDL_136 GDL_137 GDL_138 GDL_139 GDL_140 GDL_141 GDL_142 GDL_143 GDL_144
+  GDL_145 GDL_146 GDL_147 GDL_148 GDL_149 GDL_150 GDL_151 GDL_152 GDL_153
+  GDL_154 GDL_155 GDL_156 GDL_157 GDL_158 GDL_159 GDL_160 GDL_161 GDL_162
+  GDL_163 GDL_164 GDL_165 GDL_166 GDL_167 GDL_168 GDL_169 GDL_170 GDL_171
+  GDL_172 GDL_173 GDL_174 GDL_175 GDL_176 GDL_177 GDL_178 GDL_179 GDL_180
+  GDL_181 GDL_182 GDL_183 GDL_184 GDL_185 GDL_186 GDL_187 GDL_188 GDL_189
+  GDL_190 GDL_191 GDL_192 GDL_193 GDL_194 GDL_195 GDL_196 GDL_197 GDL_198
+  GDL_199 GDL_200 GDL_201 GDL_202 GDL_203 GDL_204 GDL_205 GDL_206 GDL_207
+  GDL_208 GDL_209 GDL_210 GDL_211 GDL_212 GDL_213 GDL_214 GDL_215 GDL_216
+  GDL_217 GDL_218 GDL_219 GDL_220 GDL_221 GDL_222 GDL_223 GDL_224 GDL_225
+  GDL_226 GDL_227 GDL_228 GDL_229 GDL_230 GDL_231 GDL_232 GDL_233 GDL_234
+  GDL_235 GDL_236 GDL_237 GDL_238 GDL_239 GDL_240 GDL_241 GDL_242 GDL_243
+  GDL_244 GDL_245 GDL_246 GDL_247 GDL_248 GDL_249 GDL_250 GDL_251 GDL_252
+  GDL_253 GDL_254 GDL_255 GDL_256 GDL_257 GTPD GTPDE GTP_0 GTP_1 IRET LGWEN
+  MBL_0 MBL_1 MGDLE MGDLS MGTPE MGTPS_0 MGTPS_1 MWLLATE PG0_0 PG0_1 PG0_2
+  PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13
+  PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23
+  PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33
+  PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43
+  PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53
+  PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63
+  PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73
+  PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83
+  PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93
+  PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103
+  PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112
+  PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121
+  PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 PG0_129 PG0_130
+  PG0_131 PG0_132 PG0_133 PG0_134 PG0_135 PG0_136 PG0_137 PG0_138 PG0_139
+  PG0_140 PG0_141 PG0_142 PG0_143 PG0_144 PG0_145 PG0_146 PG0_147 PG0_148
+  PG0_149 PG0_150 PG0_151 PG0_152 PG0_153 PG0_154 PG0_155 PG0_156 PG0_157
+  PG0_158 PG0_159 PG0_160 PG0_161 PG0_162 PG0_163 PG0_164 PG0_165 PG0_166
+  PG0_167 PG0_168 PG0_169 PG0_170 PG0_171 PG0_172 PG0_173 PG0_174 PG0_175
+  PG0_176 PG0_177 PG0_178 PG0_179 PG0_180 PG0_181 PG0_182 PG0_183 PG0_184
+  PG0_185 PG0_186 PG0_187 PG0_188 PG0_189 PG0_190 PG0_191 PG0_192 PG0_193
+  PG0_194 PG0_195 PG0_196 PG0_197 PG0_198 PG0_199 PG0_200 PG0_201 PG0_202
+  PG0_203 PG0_204 PG0_205 PG0_206 PG0_207 PG0_208 PG0_209 PG0_210 PG0_211
+  PG0_212 PG0_213 PG0_214 PG0_215 PG0_216 PG0_217 PG0_218 PG0_219 PG0_220
+  PG0_221 PG0_222 PG0_223 PG0_224 PG0_225 PG0_226 PG0_227 PG0_228 PG0_229
+  PG0_230 PG0_231 PG0_232 PG0_233 PG0_234 PG0_235 PG0_236 PG0_237 PG0_238
+  PG0_239 PG0_240 PG0_241 PG0_242 PG0_243 PG0_244 PG0_245 PG0_246 PG0_247
+  PG0_248 PG0_249 PG0_250 PG0_251 PG0_252 PG0_253 PG0_254 PG0_255 PG0_256
+  PG0_257 RDTN RRBTP RRBTP_TERM RREN RXP0_0 RXP0_1 RXP1_0 RXP1_1 RXP2_0
+  RXP2_1 RXP3_0 RXP3_1 TIEHIGH_TERM TL0_0 TL0_1 TL0_2 TL0_3 TL1_0 TL1_1 WBT
+  XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
** lut_sram_1024x16BK0B16X64: 104873 flat devices **
XLEFTCOREBANK0 BL_128 BL_127 BL_126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120
+  BL_119 BL_118 BL_117 BL_116 BL_115 BL_114 BL_113 BL_112 BL_111 BL_110
+  BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL_103 BL_102 BL_101 BL_100 BL_99
+  BL_98 BL_97 BL_96 BL_95 BL_94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87
+  BL_86 BL_85 BL_84 BL_83 BL_82 BL_81 BL_80 BL_79 BL_78 BL_77 BL_76 BL_75
+  BL_74 BL_73 BL_72 BL_71 BL_70 BL_69 BL_68 BL_67 BL_66 BL_65 BL_64 BL_63
+  BL_62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL_54 BL_53 BL_52 BL_51
+  BL_50 BL_49 BL_48 BL_47 BL_46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL_39
+  BL_38 BL_37 BL_36 BL_35 BL_34 BL_33 BL_32 BL_31 BL_30 BL_29 BL_28 BL_27
+  BL_26 BL_25 BL_24 BL_23 BL_22 BL_21 BL_20 BL_19 BL_18 BL_17 BL_16 BL_15
+  BL_14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL_6 BL_5 BL_4 BL_3 BL_2 BL_1
+  BL_0 BL__127 BL__126 BL__125 BL__124 BL__123 BL__122 BL__121 BL__120
+  BL__119 BL__118 BL__117 BL__116 BL__115 BL__114 BL__113 BL__112 BL__111
+  BL__110 BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BL__103 BL__102
+  BL__101 BL__100 BL__99 BL__98 BL__97 BL__96 BL__95 BL__94 BL__93 BL__92
+  BL__91 BL__90 BL__89 BL__88 BL__87 BL__86 BL__85 BL__84 BL__83 BL__82
+  BL__81 BL__80 BL__79 BL__78 BL__77 BL__76 BL__75 BL__74 BL__73 BL__72
+  BL__71 BL__70 BL__69 BL__68 BL__67 BL__66 BL__65 BL__64 BL__63 BL__62
+  BL__61 BL__60 BL__59 BL__58 BL__57 BL__56 BL__55 BL__54 BL__53 BL__52
+  BL__51 BL__50 BL__49 BL__48 BL__47 BL__46 BL__45 BL__44 BL__43 BL__42
+  BL__41 BL__40 BL__39 BL__38 BL__37 BL__36 BL__35 BL__34 BL__33 BL__32
+  BL__31 BL__30 BL__29 BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 BL__22
+  BL__21 BL__20 BL__19 BL__18 BL__17 BL__16 BL__15 BL__14 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 BL__6 BL__5 BL__4 BL__3 BL__2 BL__1 BL__0
+  GDL_128 GDL_127 GDL_126 GDL_125 GDL_124 GDL_123 GDL_122 GDL_121 GDL_120
+  GDL_119 GDL_118 GDL_117 GDL_116 GDL_115 GDL_114 GDL_113 GDL_112 GDL_111
+  GDL_110 GDL_109 GDL_108 GDL_107 GDL_106 GDL_105 GDL_104 GDL_103 GDL_102
+  GDL_101 GDL_100 GDL_99 GDL_98 GDL_97 GDL_96 GDL_95 GDL_94 GDL_93 GDL_92
+  GDL_91 GDL_90 GDL_89 GDL_88 GDL_87 GDL_86 GDL_85 GDL_84 GDL_83 GDL_82
+  GDL_81 GDL_80 GDL_79 GDL_78 GDL_77 GDL_76 GDL_75 GDL_74 GDL_73 GDL_72
+  GDL_71 GDL_70 GDL_69 GDL_68 GDL_67 GDL_66 GDL_65 GDL_64 GDL_63 GDL_62
+  GDL_61 GDL_60 GDL_59 GDL_58 GDL_57 GDL_56 GDL_55 GDL_54 GDL_53 GDL_52
+  GDL_51 GDL_50 GDL_49 GDL_48 GDL_47 GDL_46 GDL_45 GDL_44 GDL_43 GDL_42
+  GDL_41 GDL_40 GDL_39 GDL_38 GDL_37 GDL_36 GDL_35 GDL_34 GDL_33 GDL_32
+  GDL_31 GDL_30 GDL_29 GDL_28 GDL_27 GDL_26 GDL_25 GDL_24 GDL_23 GDL_22
+  GDL_21 GDL_20 GDL_19 GDL_18 GDL_17 GDL_16 GDL_15 GDL_14 GDL_13 GDL_12
+  GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0
+  MBL_1 PG0_128 PG0_127 PG0_126 PG0_125 PG0_124 PG0_123 PG0_122 PG0_121
+  PG0_120 PG0_119 PG0_118 PG0_117 PG0_116 PG0_115 PG0_114 PG0_113 PG0_112
+  PG0_111 PG0_110 PG0_109 PG0_108 PG0_107 PG0_106 PG0_105 PG0_104 PG0_103
+  PG0_102 PG0_101 PG0_100 PG0_99 PG0_98 PG0_97 PG0_96 PG0_95 PG0_94 PG0_93
+  PG0_92 PG0_91 PG0_90 PG0_89 PG0_88 PG0_87 PG0_86 PG0_85 PG0_84 PG0_83
+  PG0_82 PG0_81 PG0_80 PG0_79 PG0_78 PG0_77 PG0_76 PG0_75 PG0_74 PG0_73
+  PG0_72 PG0_71 PG0_70 PG0_69 PG0_68 PG0_67 PG0_66 PG0_65 PG0_64 PG0_63
+  PG0_62 PG0_61 PG0_60 PG0_59 PG0_58 PG0_57 PG0_56 PG0_55 PG0_54 PG0_53
+  PG0_52 PG0_51 PG0_50 PG0_49 PG0_48 PG0_47 PG0_46 PG0_45 PG0_44 PG0_43
+  PG0_42 PG0_41 PG0_40 PG0_39 PG0_38 PG0_37 PG0_36 PG0_35 PG0_34 PG0_33
+  PG0_32 PG0_31 PG0_30 PG0_29 PG0_28 PG0_27 PG0_26 PG0_25 PG0_24 PG0_23
+  PG0_22 PG0_21 PG0_20 PG0_19 PG0_18 PG0_17 PG0_16 PG0_15 PG0_14 PG0_13
+  PG0_12 PG0_11 PG0_10 PG0_9 PG0_8 PG0_7 PG0_6 PG0_5 PG0_4 PG0_3 PG0_2 PG0_1
+  PG0_0 TL0_1 TL0_0 TL1_0 WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 MBL_1 MBL_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16CABL128X64TT
XRIGHTCOREBANK0 BL_129 BL_130 BL_131 BL_132 BL_133 BL_134 BL_135 BL_136 BL_137
+  BL_138 BL_139 BL_140 BL_141 BL_142 BL_143 BL_144 BL_145 BL_146 BL_147
+  BL_148 BL_149 BL_150 BL_151 BL_152 BL_153 BL_154 BL_155 BL_156 BL_157
+  BL_158 BL_159 BL_160 BL_161 BL_162 BL_163 BL_164 BL_165 BL_166 BL_167
+  BL_168 BL_169 BL_170 BL_171 BL_172 BL_173 BL_174 BL_175 BL_176 BL_177
+  BL_178 BL_179 BL_180 BL_181 BL_182 BL_183 BL_184 BL_185 BL_186 BL_187
+  BL_188 BL_189 BL_190 BL_191 BL_192 BL_193 BL_194 BL_195 BL_196 BL_197
+  BL_198 BL_199 BL_200 BL_201 BL_202 BL_203 BL_204 BL_205 BL_206 BL_207
+  BL_208 BL_209 BL_210 BL_211 BL_212 BL_213 BL_214 BL_215 BL_216 BL_217
+  BL_218 BL_219 BL_220 BL_221 BL_222 BL_223 BL_224 BL_225 BL_226 BL_227
+  BL_228 BL_229 BL_230 BL_231 BL_232 BL_233 BL_234 BL_235 BL_236 BL_237
+  BL_238 BL_239 BL_240 BL_241 BL_242 BL_243 BL_244 BL_245 BL_246 BL_247
+  BL_248 BL_249 BL_250 BL_251 BL_252 BL_253 BL_254 BL_255 BL_256 BL_257
+  BL__128 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134 BL__135 BL__136
+  BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL__143 BL__144 BL__145
+  BL__146 BL__147 BL__148 BL__149 BL__150 BL__151 BL__152 BL__153 BL__154
+  BL__155 BL__156 BL__157 BL__158 BL__159 BL__160 BL__161 BL__162 BL__163
+  BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170 BL__171 BL__172
+  BL__173 BL__174 BL__175 BL__176 BL__177 BL__178 BL__179 BL__180 BL__181
+  BL__182 BL__183 BL__184 BL__185 BL__186 BL__187 BL__188 BL__189 BL__190
+  BL__191 BL__192 BL__193 BL__194 BL__195 BL__196 BL__197 BL__198 BL__199
+  BL__200 BL__201 BL__202 BL__203 BL__204 BL__205 BL__206 BL__207 BL__208
+  BL__209 BL__210 BL__211 BL__212 BL__213 BL__214 BL__215 BL__216 BL__217
+  BL__218 BL__219 BL__220 BL__221 BL__222 BL__223 BL__224 BL__225 BL__226
+  BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233 BL__234 BL__235
+  BL__236 BL__237 BL__238 BL__239 BL__240 BL__241 BL__242 BL__243 BL__244
+  BL__245 BL__246 BL__247 BL__248 BL__249 BL__250 BL__251 BL__252 BL__253
+  BL__254 BL__255 GDL_129 GDL_130 GDL_131 GDL_132 GDL_133 GDL_134 GDL_135
+  GDL_136 GDL_137 GDL_138 GDL_139 GDL_140 GDL_141 GDL_142 GDL_143 GDL_144
+  GDL_145 GDL_146 GDL_147 GDL_148 GDL_149 GDL_150 GDL_151 GDL_152 GDL_153
+  GDL_154 GDL_155 GDL_156 GDL_157 GDL_158 GDL_159 GDL_160 GDL_161 GDL_162
+  GDL_163 GDL_164 GDL_165 GDL_166 GDL_167 GDL_168 GDL_169 GDL_170 GDL_171
+  GDL_172 GDL_173 GDL_174 GDL_175 GDL_176 GDL_177 GDL_178 GDL_179 GDL_180
+  GDL_181 GDL_182 GDL_183 GDL_184 GDL_185 GDL_186 GDL_187 GDL_188 GDL_189
+  GDL_190 GDL_191 GDL_192 GDL_193 GDL_194 GDL_195 GDL_196 GDL_197 GDL_198
+  GDL_199 GDL_200 GDL_201 GDL_202 GDL_203 GDL_204 GDL_205 GDL_206 GDL_207
+  GDL_208 GDL_209 GDL_210 GDL_211 GDL_212 GDL_213 GDL_214 GDL_215 GDL_216
+  GDL_217 GDL_218 GDL_219 GDL_220 GDL_221 GDL_222 GDL_223 GDL_224 GDL_225
+  GDL_226 GDL_227 GDL_228 GDL_229 GDL_230 GDL_231 GDL_232 GDL_233 GDL_234
+  GDL_235 GDL_236 GDL_237 GDL_238 GDL_239 GDL_240 GDL_241 GDL_242 GDL_243
+  GDL_244 GDL_245 GDL_246 GDL_247 GDL_248 GDL_249 GDL_250 GDL_251 GDL_252
+  GDL_253 GDL_254 GDL_255 GDL_256 GDL_257 MBL_0 PG0_129 PG0_130 PG0_131
+  PG0_132 PG0_133 PG0_134 PG0_135 PG0_136 PG0_137 PG0_138 PG0_139 PG0_140
+  PG0_141 PG0_142 PG0_143 PG0_144 PG0_145 PG0_146 PG0_147 PG0_148 PG0_149
+  PG0_150 PG0_151 PG0_152 PG0_153 PG0_154 PG0_155 PG0_156 PG0_157 PG0_158
+  PG0_159 PG0_160 PG0_161 PG0_162 PG0_163 PG0_164 PG0_165 PG0_166 PG0_167
+  PG0_168 PG0_169 PG0_170 PG0_171 PG0_172 PG0_173 PG0_174 PG0_175 PG0_176
+  PG0_177 PG0_178 PG0_179 PG0_180 PG0_181 PG0_182 PG0_183 PG0_184 PG0_185
+  PG0_186 PG0_187 PG0_188 PG0_189 PG0_190 PG0_191 PG0_192 PG0_193 PG0_194
+  PG0_195 PG0_196 PG0_197 PG0_198 PG0_199 PG0_200 PG0_201 PG0_202 PG0_203
+  PG0_204 PG0_205 PG0_206 PG0_207 PG0_208 PG0_209 PG0_210 PG0_211 PG0_212
+  PG0_213 PG0_214 PG0_215 PG0_216 PG0_217 PG0_218 PG0_219 PG0_220 PG0_221
+  PG0_222 PG0_223 PG0_224 PG0_225 PG0_226 PG0_227 PG0_228 PG0_229 PG0_230
+  PG0_231 PG0_232 PG0_233 PG0_234 PG0_235 PG0_236 PG0_237 PG0_238 PG0_239
+  PG0_240 PG0_241 PG0_242 PG0_243 PG0_244 PG0_245 PG0_246 PG0_247 PG0_248
+  PG0_249 PG0_250 PG0_251 PG0_252 PG0_253 PG0_254 PG0_255 PG0_256 PG0_257
+  TL0_2 TL0_3 TL1_1 WL0R_31 WL1R_31 WL1R_30 WL0R_30 WL0R_29 WL1R_29 WL1R_28
+  WL0R_28 WL0R_27 WL1R_27 WL1R_26 WL0R_26 WL0R_25 WL1R_25 WL1R_24 WL0R_24
+  WL0R_23 WL1R_23 WL1R_22 WL0R_22 WL0R_21 WL1R_21 WL1R_20 WL0R_20 WL0R_19
+  WL1R_19 WL1R_18 WL0R_18 WL0R_17 WL1R_17 WL1R_16 WL0R_16 WL0R_15 WL1R_15
+  WL1R_14 WL0R_14 WL0R_13 WL1R_13 WL1R_12 WL0R_12 WL0R_11 WL1R_11 WL1R_10
+  WL0R_10 WL0R_9 WL1R_9 WL1R_8 WL0R_8 WL0R_7 WL1R_7 WL1R_6 WL0R_6 WL0R_5
+  WL1R_5 WL1R_4 WL0R_4 WL0R_3 WL1R_3 WL1R_2 WL0R_2 WL0R_1 WL1R_1 WL1R_0
+  WL0R_0 MBL_1 MWLLATE VSSE VDDPE VDDCE lut_sram_1024x16CABR128X64TT
XWDBANK0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK
+  AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 BTP2 BTP3 G0_TIEHIGH G1_TIEHIGH GTPD
+  GTPDE GTP_1 GTP_0 LGWEN MBL_0 MGDLE MGDLS MGTPE MGTPS_1 MGTPS_0 MWLLATE
+  MWLLATE RDTN IRET RRBTP RRBTP_TERM RREN RXP0_1 RXP0_0 RXP1_1 RXP1_0 RXP2_1
+  RXP2_0 RXP3_1 RXP3_0 TIEHIGH_TERM MBL_1 WBT WL_63 WL_60 WL_59 WL_56 WL_55
+  WL_52 WL_51 WL_48 WL_47 WL_44 WL_43 WL_40 WL_39 WL_36 WL_35 WL_32 WL_31
+  WL_28 WL_27 WL_24 WL_23 WL_20 WL_19 WL_16 WL_15 WL_12 WL_11 WL_8 WL_7 WL_4
+  WL_3 WL_0 WL0R_0 WL0R_1 WL0R_2 WL0R_3 WL0R_4 WL0R_5 WL0R_6 WL0R_7 WL0R_8
+  WL0R_9 WL0R_10 WL0R_11 WL0R_12 WL0R_13 WL0R_14 WL0R_15 WL0R_16 WL0R_17
+  WL0R_18 WL0R_19 WL0R_20 WL0R_21 WL0R_22 WL0R_23 WL0R_24 WL0R_25 WL0R_26
+  WL0R_27 WL0R_28 WL0R_29 WL0R_30 WL0R_31 WL_62 WL_61 WL_58 WL_57 WL_54 WL_53
+  WL_50 WL_49 WL_46 WL_45 WL_42 WL_41 WL_38 WL_37 WL_34 WL_33 WL_30 WL_29
+  WL_26 WL_25 WL_22 WL_21 WL_18 WL_17 WL_14 WL_13 WL_10 WL_9 WL_6 WL_5 WL_2
+  WL_1 WL1R_0 WL1R_1 WL1R_2 WL1R_3 WL1R_4 WL1R_5 WL1R_6 WL1R_7 WL1R_8 WL1R_9
+  WL1R_10 WL1R_11 WL1R_12 WL1R_13 WL1R_14 WL1R_15 WL1R_16 WL1R_17 WL1R_18
+  WL1R_19 WL1R_20 WL1R_21 WL1R_22 WL1R_23 WL1R_24 WL1R_25 WL1R_26 WL1R_27
+  WL1R_28 WL1R_29 WL1R_30 WL1R_31 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9
+  XP10 XP11 VSSE VDDPE VDDCE lut_sram_1024x16WDSEC_SB0B64
.ENDS lut_sram_1024x16BK0B16X64
****
.SUBCKT lut_sram_1024x16BH1024X16M16 ATRACK0B ATRACK1B ATRACK2B ATRACK3B
+  ATRACK4B ATRACK5B AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK
+  AX6NB AY0NB AY0TRACK AY1NB AY1TRACK AY2NB AY2TRACK BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17
+  BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29
+  BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41
+  BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53
+  BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65
+  BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77
+  BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89
+  BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101
+  BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111
+  BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121
+  BL_122 BL_123 BL_124 BL_125 BL_126 BL_127 BL_128 BL_129 BL_130 BL_131
+  BL_132 BL_133 BL_134 BL_135 BL_136 BL_137 BL_138 BL_139 BL_140 BL_141
+  BL_142 BL_143 BL_144 BL_145 BL_146 BL_147 BL_148 BL_149 BL_150 BL_151
+  BL_152 BL_153 BL_154 BL_155 BL_156 BL_157 BL_158 BL_159 BL_160 BL_161
+  BL_162 BL_163 BL_164 BL_165 BL_166 BL_167 BL_168 BL_169 BL_170 BL_171
+  BL_172 BL_173 BL_174 BL_175 BL_176 BL_177 BL_178 BL_179 BL_180 BL_181
+  BL_182 BL_183 BL_184 BL_185 BL_186 BL_187 BL_188 BL_189 BL_190 BL_191
+  BL_192 BL_193 BL_194 BL_195 BL_196 BL_197 BL_198 BL_199 BL_200 BL_201
+  BL_202 BL_203 BL_204 BL_205 BL_206 BL_207 BL_208 BL_209 BL_210 BL_211
+  BL_212 BL_213 BL_214 BL_215 BL_216 BL_217 BL_218 BL_219 BL_220 BL_221
+  BL_222 BL_223 BL_224 BL_225 BL_226 BL_227 BL_228 BL_229 BL_230 BL_231
+  BL_232 BL_233 BL_234 BL_235 BL_236 BL_237 BL_238 BL_239 BL_240 BL_241
+  BL_242 BL_243 BL_244 BL_245 BL_246 BL_247 BL_248 BL_249 BL_250 BL_251
+  BL_252 BL_253 BL_254 BL_255 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BL__127 BL__128 BL__129 BL__130 BL__131 BL__132 BL__133 BL__134
+  BL__135 BL__136 BL__137 BL__138 BL__139 BL__140 BL__141 BL__142 BL__143
+  BL__144 BL__145 BL__146 BL__147 BL__148 BL__149 BL__150 BL__151 BL__152
+  BL__153 BL__154 BL__155 BL__156 BL__157 BL__158 BL__159 BL__160 BL__161
+  BL__162 BL__163 BL__164 BL__165 BL__166 BL__167 BL__168 BL__169 BL__170
+  BL__171 BL__172 BL__173 BL__174 BL__175 BL__176 BL__177 BL__178 BL__179
+  BL__180 BL__181 BL__182 BL__183 BL__184 BL__185 BL__186 BL__187 BL__188
+  BL__189 BL__190 BL__191 BL__192 BL__193 BL__194 BL__195 BL__196 BL__197
+  BL__198 BL__199 BL__200 BL__201 BL__202 BL__203 BL__204 BL__205 BL__206
+  BL__207 BL__208 BL__209 BL__210 BL__211 BL__212 BL__213 BL__214 BL__215
+  BL__216 BL__217 BL__218 BL__219 BL__220 BL__221 BL__222 BL__223 BL__224
+  BL__225 BL__226 BL__227 BL__228 BL__229 BL__230 BL__231 BL__232 BL__233
+  BL__234 BL__235 BL__236 BL__237 BL__238 BL__239 BL__240 BL__241 BL__242
+  BL__243 BL__244 BL__245 BL__246 BL__247 BL__248 BL__249 BL__250 BL__251
+  BL__252 BL__253 BL__254 BL__255 BS0 BS1 BTP0 BTP1 BTP2 BTP3 G0_TIEHIGH
+  G1_TIEHIGH GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6 GDLB_7 GDLB_8
+  GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15 GDLB_16 GDLB_17
+  GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23 GDLB_24 GDLB_25 GDLB_26
+  GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB__0 GDLB__1 GDLB__2 GDLB__3
+  GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8 GDLB__9 GDLB__10 GDLB__11 GDLB__12
+  GDLB__13 GDLB__14 GDLB__15 GDLB__16 GDLB__17 GDLB__18 GDLB__19 GDLB__20
+  GDLB__21 GDLB__22 GDLB__23 GDLB__24 GDLB__25 GDLB__26 GDLB__27 GDLB__28
+  GDLB__29 GDLB__30 GDLB__31 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7
+  GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18
+  GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28
+  GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38
+  GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48
+  GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58
+  GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GTP GTPB GTPD GTPDB GTPDE LGWEN MBL_0
+  MBL_1 MGTPE MGTPS_0 MGTPS_1 MWLLATE RDTN RET RRBTP RREN RRENB RXP0_0 RXP0_1
+  RXP1_0 RXP1_1 RXP2_0 RXP2_1 RXP3_0 RXP3_1 TL0_0 TL0_1 TL0_2 WBTDD XP0 XP1
+  XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
** lut_sram_1024x16BH1024X16M16: 109936 flat devices **
XBANK0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  AY2TRACK BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11
+  BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23
+  BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35
+  BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47
+  BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59
+  BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71
+  BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83
+  BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95
+  BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106
+  BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116
+  BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126
+  BL_127 VSSE VSSE BL_128 BL_129 BL_130 BL_131 BL_132 BL_133 BL_134 BL_135
+  BL_136 BL_137 BL_138 BL_139 BL_140 BL_141 BL_142 BL_143 BL_144 BL_145
+  BL_146 BL_147 BL_148 BL_149 BL_150 BL_151 BL_152 BL_153 BL_154 BL_155
+  BL_156 BL_157 BL_158 BL_159 BL_160 BL_161 BL_162 BL_163 BL_164 BL_165
+  BL_166 BL_167 BL_168 BL_169 BL_170 BL_171 BL_172 BL_173 BL_174 BL_175
+  BL_176 BL_177 BL_178 BL_179 BL_180 BL_181 BL_182 BL_183 BL_184 BL_185
+  BL_186 BL_187 BL_188 BL_189 BL_190 BL_191 BL_192 BL_193 BL_194 BL_195
+  BL_196 BL_197 BL_198 BL_199 BL_200 BL_201 BL_202 BL_203 BL_204 BL_205
+  BL_206 BL_207 BL_208 BL_209 BL_210 BL_211 BL_212 BL_213 BL_214 BL_215
+  BL_216 BL_217 BL_218 BL_219 BL_220 BL_221 BL_222 BL_223 BL_224 BL_225
+  BL_226 BL_227 BL_228 BL_229 BL_230 BL_231 BL_232 BL_233 BL_234 BL_235
+  BL_236 BL_237 BL_238 BL_239 BL_240 BL_241 BL_242 BL_243 BL_244 BL_245
+  BL_246 BL_247 BL_248 BL_249 BL_250 BL_251 BL_252 BL_253 BL_254 BL_255 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12
+  BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22
+  BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42
+  BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50 BL__51 BL__52
+  BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60 BL__61 BL__62
+  BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BL__72
+  BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80 BL__81 BL__82
+  BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92
+  BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100 BL__101 BL__102
+  BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109 BL__110 BL__111
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BL__119 BL__120
+  BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 BL__128 BL__129
+  BL__130 BL__131 BL__132 BL__133 BL__134 BL__135 BL__136 BL__137 BL__138
+  BL__139 BL__140 BL__141 BL__142 BL__143 BL__144 BL__145 BL__146 BL__147
+  BL__148 BL__149 BL__150 BL__151 BL__152 BL__153 BL__154 BL__155 BL__156
+  BL__157 BL__158 BL__159 BL__160 BL__161 BL__162 BL__163 BL__164 BL__165
+  BL__166 BL__167 BL__168 BL__169 BL__170 BL__171 BL__172 BL__173 BL__174
+  BL__175 BL__176 BL__177 BL__178 BL__179 BL__180 BL__181 BL__182 BL__183
+  BL__184 BL__185 BL__186 BL__187 BL__188 BL__189 BL__190 BL__191 BL__192
+  BL__193 BL__194 BL__195 BL__196 BL__197 BL__198 BL__199 BL__200 BL__201
+  BL__202 BL__203 BL__204 BL__205 BL__206 BL__207 BL__208 BL__209 BL__210
+  BL__211 BL__212 BL__213 BL__214 BL__215 BL__216 BL__217 BL__218 BL__219
+  BL__220 BL__221 BL__222 BL__223 BL__224 BL__225 BL__226 BL__227 BL__228
+  BL__229 BL__230 BL__231 BL__232 BL__233 BL__234 BL__235 BL__236 BL__237
+  BL__238 BL__239 BL__240 BL__241 BL__242 BL__243 BL__244 BL__245 BL__246
+  BL__247 BL__248 BL__249 BL__250 BL__251 BL__252 BL__253 BL__254 BL__255 BS0
+  BS1 BTP0 BTP1 BTP2 BTP3 G0_TIEHIGH G1_TIEHIGH VSSE GDL_0 VDDCE VSSE VSSE
+  VDDCE GDL_1 VSSE VSSE GDL_2 VDDCE VSSE VSSE VDDCE GDL_3 VSSE VSSE GDL_4
+  VDDCE VSSE VSSE VDDCE GDL_5 VSSE VSSE GDL_6 VDDCE VSSE VSSE VDDCE GDL_7
+  VSSE VSSE GDL_8 VDDCE VSSE VSSE VDDCE GDL_9 VSSE VSSE GDL_10 VDDCE VSSE
+  VSSE VDDCE GDL_11 VSSE VSSE GDL_12 VDDCE VSSE VSSE VDDCE GDL_13 VSSE VSSE
+  GDL_14 VDDCE VSSE VSSE VDDCE GDL_15 VSSE VSSE GDL_16 VDDCE VSSE VSSE VDDCE
+  GDL_17 VSSE VSSE GDL_18 VDDCE VSSE VSSE VDDCE GDL_19 VSSE VSSE GDL_20 VDDCE
+  VSSE VSSE VDDCE GDL_21 VSSE VSSE GDL_22 VDDCE VSSE VSSE VDDCE GDL_23 VSSE
+  VSSE GDL_24 VDDCE VSSE VSSE VDDCE GDL_25 VSSE VSSE GDL_26 VDDCE VSSE VSSE
+  VDDCE GDL_27 VSSE VSSE GDL_28 VDDCE VSSE VSSE VDDCE GDL_29 VSSE VSSE GDL_30
+  VDDCE VSSE VSSE VDDCE GDL_31 VSSE VSSE VSSE VSSE GDL_32 VDDCE VSSE VSSE
+  VDDCE GDL_33 VSSE VSSE GDL_34 VDDCE VSSE VSSE VDDCE GDL_35 VSSE VSSE GDL_36
+  VDDCE VSSE VSSE VDDCE GDL_37 VSSE VSSE GDL_38 VDDCE VSSE VSSE VDDCE GDL_39
+  VSSE VSSE GDL_40 VDDCE VSSE VSSE VDDCE GDL_41 VSSE VSSE GDL_42 VDDCE VSSE
+  VSSE VDDCE GDL_43 VSSE VSSE GDL_44 VDDCE VSSE VSSE VDDCE GDL_45 VSSE VSSE
+  GDL_46 VDDCE VSSE VSSE VDDCE GDL_47 VSSE VSSE GDL_48 VDDCE VSSE VSSE VDDCE
+  GDL_49 VSSE VSSE GDL_50 VDDCE VSSE VSSE VDDCE GDL_51 VSSE VSSE GDL_52 VDDCE
+  VSSE VSSE VDDCE GDL_53 VSSE VSSE GDL_54 VDDCE VSSE VSSE VDDCE GDL_55 VSSE
+  VSSE GDL_56 VDDCE VSSE VSSE VDDCE GDL_57 VSSE VSSE GDL_58 VDDCE VSSE VSSE
+  VDDCE GDL_59 VSSE VSSE GDL_60 VDDCE VSSE VSSE VDDCE GDL_61 VSSE VSSE GDL_62
+  VDDCE VSSE VSSE VDDCE GDL_63 VSSE GTPD GTPDE GTPB GTP RET LGWEN MBL_1 MBL_0
+  GTPDE GTPDE MGTPE MGTPS_1 MGTPS_0 MWLLATE VSSE VDDPE VDDCE VDDPE VDDPE
+  VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE
+  VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE
+  VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE
+  VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE
+  VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE
+  VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE
+  VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE
+  VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE
+  VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE
+  VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VSSE VSSE VDDPE VDDCE
+  VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE
+  VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE
+  VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE
+  VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE
+  VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE
+  VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE
+  VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE
+  VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VDDCE VDDCE
+  VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE VSSE VDDPE VDDCE VDDPE VDDPE VDDCE
+  VDDPE VDDCE VDDCE VDDPE VDDCE VDDPE VDDPE VDDCE VDDPE VSSE RDTN RRBTP VSSE
+  RREN RXP0_1 RXP0_0 RXP1_1 RXP1_0 RXP2_1 RXP2_0 RXP3_1 RXP3_0 TIEHIGHT TL0_0
+  TL0_1 GTPDE TL0_2 TL0_0 TL0_2 WBTDD XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9
+  XP10 XP11 VSSE VDDPE VDDCE lut_sram_1024x16BK0B16X64
XCHANNEL0 ATRACK0B AX0TRACK ATRACK1B AX1TRACK ATRACK2B AX2TRACK ATRACK3B
+  AX3TRACK ATRACK4B AX4TRACK ATRACK5B AX5TRACK AX6NB AY0NB AY0TRACK AY1NB
+  AY1TRACK AY2NB AY2TRACK BL_0 BL_15 BL_16 BL_31 BL_32 BL_47 BL_48 BL_63
+  BL_64 BL_79 BL_80 BL_95 BL_96 BL_111 BL_112 BL_127 BL_128 BL_143 BL_144
+  BL_159 BL_160 BL_175 BL_176 BL_191 BL_192 BL_207 BL_208 BL_223 BL_224
+  BL_239 BL_240 BL_255 BL__0 BL__15 BL__16 BL__31 BL__32 BL__47 BL__48 BL__63
+  BL__64 BL__79 BL__80 BL__95 BL__96 BL__111 BL__112 BL__127 BL__128 BL__143
+  BL__144 BL__159 BL__160 BL__175 BL__176 BL__191 BL__192 BL__207 BL__208
+  BL__223 BL__224 BL__239 BL__240 BL__255 BL_1 BL_14 BL_17 BL_30 BL_33 BL_46
+  BL_49 BL_62 BL_65 BL_78 BL_81 BL_94 BL_97 BL_110 BL_113 BL_126 BL_129
+  BL_142 BL_145 BL_158 BL_161 BL_174 BL_177 BL_190 BL_193 BL_206 BL_209
+  BL_222 BL_225 BL_238 BL_241 BL_254 BL__1 BL__14 BL__17 BL__30 BL__33 BL__46
+  BL__49 BL__62 BL__65 BL__78 BL__81 BL__94 BL__97 BL__110 BL__113 BL__126
+  BL__129 BL__142 BL__145 BL__158 BL__161 BL__174 BL__177 BL__190 BL__193
+  BL__206 BL__209 BL__222 BL__225 BL__238 BL__241 BL__254 BL_2 BL_13 BL_18
+  BL_29 BL_34 BL_45 BL_50 BL_61 BL_66 BL_77 BL_82 BL_93 BL_98 BL_109 BL_114
+  BL_125 BL_130 BL_141 BL_146 BL_157 BL_162 BL_173 BL_178 BL_189 BL_194
+  BL_205 BL_210 BL_221 BL_226 BL_237 BL_242 BL_253 BL__2 BL__13 BL__18 BL__29
+  BL__34 BL__45 BL__50 BL__61 BL__66 BL__77 BL__82 BL__93 BL__98 BL__109
+  BL__114 BL__125 BL__130 BL__141 BL__146 BL__157 BL__162 BL__173 BL__178
+  BL__189 BL__194 BL__205 BL__210 BL__221 BL__226 BL__237 BL__242 BL__253
+  BL_3 BL_12 BL_19 BL_28 BL_35 BL_44 BL_51 BL_60 BL_67 BL_76 BL_83 BL_92
+  BL_99 BL_108 BL_115 BL_124 BL_131 BL_140 BL_147 BL_156 BL_163 BL_172 BL_179
+  BL_188 BL_195 BL_204 BL_211 BL_220 BL_227 BL_236 BL_243 BL_252 BL__3 BL__12
+  BL__19 BL__28 BL__35 BL__44 BL__51 BL__60 BL__67 BL__76 BL__83 BL__92
+  BL__99 BL__108 BL__115 BL__124 BL__131 BL__140 BL__147 BL__156 BL__163
+  BL__172 BL__179 BL__188 BL__195 BL__204 BL__211 BL__220 BL__227 BL__236
+  BL__243 BL__252 BL_4 BL_11 BL_20 BL_27 BL_36 BL_43 BL_52 BL_59 BL_68 BL_75
+  BL_84 BL_91 BL_100 BL_107 BL_116 BL_123 BL_132 BL_139 BL_148 BL_155 BL_164
+  BL_171 BL_180 BL_187 BL_196 BL_203 BL_212 BL_219 BL_228 BL_235 BL_244
+  BL_251 BL__4 BL__11 BL__20 BL__27 BL__36 BL__43 BL__52 BL__59 BL__68 BL__75
+  BL__84 BL__91 BL__100 BL__107 BL__116 BL__123 BL__132 BL__139 BL__148
+  BL__155 BL__164 BL__171 BL__180 BL__187 BL__196 BL__203 BL__212 BL__219
+  BL__228 BL__235 BL__244 BL__251 BL_5 BL_10 BL_21 BL_26 BL_37 BL_42 BL_53
+  BL_58 BL_69 BL_74 BL_85 BL_90 BL_101 BL_106 BL_117 BL_122 BL_133 BL_138
+  BL_149 BL_154 BL_165 BL_170 BL_181 BL_186 BL_197 BL_202 BL_213 BL_218
+  BL_229 BL_234 BL_245 BL_250 BL__5 BL__10 BL__21 BL__26 BL__37 BL__42 BL__53
+  BL__58 BL__69 BL__74 BL__85 BL__90 BL__101 BL__106 BL__117 BL__122 BL__133
+  BL__138 BL__149 BL__154 BL__165 BL__170 BL__181 BL__186 BL__197 BL__202
+  BL__213 BL__218 BL__229 BL__234 BL__245 BL__250 BL_6 BL_9 BL_22 BL_25 BL_38
+  BL_41 BL_54 BL_57 BL_70 BL_73 BL_86 BL_89 BL_102 BL_105 BL_118 BL_121
+  BL_134 BL_137 BL_150 BL_153 BL_166 BL_169 BL_182 BL_185 BL_198 BL_201
+  BL_214 BL_217 BL_230 BL_233 BL_246 BL_249 BL__6 BL__9 BL__22 BL__25 BL__38
+  BL__41 BL__54 BL__57 BL__70 BL__73 BL__86 BL__89 BL__102 BL__105 BL__118
+  BL__121 BL__134 BL__137 BL__150 BL__153 BL__166 BL__169 BL__182 BL__185
+  BL__198 BL__201 BL__214 BL__217 BL__230 BL__233 BL__246 BL__249 BL_7 BL_8
+  BL_23 BL_24 BL_39 BL_40 BL_55 BL_56 BL_71 BL_72 BL_87 BL_88 BL_103 BL_104
+  BL_119 BL_120 BL_135 BL_136 BL_151 BL_152 BL_167 BL_168 BL_183 BL_184
+  BL_199 BL_200 BL_215 BL_216 BL_231 BL_232 BL_247 BL_248 BL__7 BL__8 BL__23
+  BL__24 BL__39 BL__40 BL__55 BL__56 BL__71 BL__72 BL__87 BL__88 BL__103
+  BL__104 BL__119 BL__120 BL__135 BL__136 BL__151 BL__152 BL__167 BL__168
+  BL__183 BL__184 BL__199 BL__200 BL__215 BL__216 BL__231 BL__232 BL__247
+  BL__248 BS0 BS1 BTP2 BTP3 BTP0 BTP1 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4
+  GDLB_5 GDLB_6 GDLB_7 GDLB_8 GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14
+  GDLB_15 GDLB_16 GDLB_17 GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23
+  GDLB_24 GDLB_25 GDLB_26 GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB__0
+  GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8 GDLB__9
+  GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14 GDLB__15 GDLB__16 GDLB__17
+  GDLB__18 GDLB__19 GDLB__20 GDLB__21 GDLB__22 GDLB__23 GDLB__24 GDLB__25
+  GDLB__26 GDLB__27 GDLB__28 GDLB__29 GDLB__30 GDLB__31 GDL_0 GDL_3 GDL_4
+  GDL_7 GDL_8 GDL_11 GDL_12 GDL_15 GDL_16 GDL_19 GDL_20 GDL_23 GDL_24 GDL_27
+  GDL_28 GDL_31 GDL_32 GDL_35 GDL_36 GDL_39 GDL_40 GDL_43 GDL_44 GDL_47
+  GDL_48 GDL_51 GDL_52 GDL_55 GDL_56 GDL_59 GDL_60 GDL_63 GDL_1 GDL_2 GDL_5
+  GDL_6 GDL_9 GDL_10 GDL_13 GDL_14 GDL_17 GDL_18 GDL_21 GDL_22 GDL_25 GDL_26
+  GDL_29 GDL_30 GDL_33 GDL_34 GDL_37 GDL_38 GDL_41 GDL_42 GDL_45 GDL_46
+  GDL_49 GDL_50 GDL_53 GDL_54 GDL_57 GDL_58 GDL_61 GDL_62 GTPB GTPDB GTPD
+  LGWEN MBL_1 GTPDE MGTPE MGTPS_1 MWLLATE RDTN RET RRENB RREN RXP0_1 RXP1_1
+  RXP2_1 RXP3_1 TL0_1 TIEHIGHT TL0_0 TL0_2 WBTDD XP1 XP0 XP3 XP2 XP5 XP4 XP7
+  XP6 XP9 XP8 XP11 XP10 VSSE VDDPE VDDCE lut_sram_1024x16CHSBB0_16M16
.ENDS lut_sram_1024x16BH1024X16M16
****
.SUBCKT lut_sram_1024x16F1024X16M16 AI0 AI1 AI2 AI3 AI5 AI6 AI7 AI8 AI9 AI10
+  AI11 CEN CLK CREN D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12
+  D_13 D_14 D_15 EMA0 EMA1 EMA2 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10
+  Q_11 Q_12 Q_13 Q_14 Q_15 RETN WEN VSSE VDDPE VDDCE
** lut_sram_1024x16F1024X16M16: 114957 flat devices **
XFPIOROW AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4N AI5 AI5N AI6 AI6N AI7 AI7N
+  AI8 AI8N AI9 AI9N AI10 AI10N AI11N AI12N AI13N BWEI_0 BWEI_1 BWEI_2 BWEI_3
+  BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13
+  BWEI_14 BWEI_15 CEI CEN CLK CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6
+  DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 D_0 D_1 D_2 D_3
+  D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14 D_15 EMA0 EMA1 EMA2 RET_15
+  RETN_TERM_15 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13
+  Q_14 Q_15 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 Q__11
+  Q__12 Q__13 Q__14 Q__15 RETN RETN_TERM_15 RETN_TERM_15 RETN_TERM_15
+  RETN_TERM_15 RETN_TERM_15 RETN_TERM_15 RETN_TERM_15 RETN_TERM_15
+  RETN_TERM_15 RETN_TERM_15 RETN_TERM_15 RETN_TERM_15 RETN_TERM_15
+  RETN_TERM_15 RETN_TERM_15 RETN_TERM_15 RET_15 RET_15 RET_15 RET_15 RET_15
+  RET_15 RET_15 RET_15 RET_15 RET_15 RET_15 RET_15 RET_15 RET_15 RET_15
+  RET_15 AI11 WEI WEN VSSE VDDPE VDDCE lut_sram_1024x16BR16FPIO8
XHALF_MEM AX0N AX1N AX2N AX3N AX4N AX5N VSSE VSSE VSSE VSSE VSSE VSSE AX6N
+  AY0N VSSE AY1N VSSE AY2N VSSE BL0_0 BL1_0 BL2_0 BL3_0 BL4_0 BL5_0 BL6_0
+  BL7_0 BL7_1 BL6_1 BL5_1 BL4_1 BL3_1 BL2_1 BL1_1 BL0_1 BL0_2 BL1_2 BL2_2
+  BL3_2 BL4_2 BL5_2 BL6_2 BL7_2 BL7_3 BL6_3 BL5_3 BL4_3 BL3_3 BL2_3 BL1_3
+  BL0_3 BL0_4 BL1_4 BL2_4 BL3_4 BL4_4 BL5_4 BL6_4 BL7_4 BL7_5 BL6_5 BL5_5
+  BL4_5 BL3_5 BL2_5 BL1_5 BL0_5 BL0_6 BL1_6 BL2_6 BL3_6 BL4_6 BL5_6 BL6_6
+  BL7_6 BL7_7 BL6_7 BL5_7 BL4_7 BL3_7 BL2_7 BL1_7 BL0_7 BL0_8 BL1_8 BL2_8
+  BL3_8 BL4_8 BL5_8 BL6_8 BL7_8 BL7_9 BL6_9 BL5_9 BL4_9 BL3_9 BL2_9 BL1_9
+  BL0_9 BL0_10 BL1_10 BL2_10 BL3_10 BL4_10 BL5_10 BL6_10 BL7_10 BL7_11 BL6_11
+  BL5_11 BL4_11 BL3_11 BL2_11 BL1_11 BL0_11 BL0_12 BL1_12 BL2_12 BL3_12
+  BL4_12 BL5_12 BL6_12 BL7_12 BL7_13 BL6_13 BL5_13 BL4_13 BL3_13 BL2_13
+  BL1_13 BL0_13 BL0_14 BL1_14 BL2_14 BL3_14 BL4_14 BL5_14 BL6_14 BL7_14
+  BL7_15 BL6_15 BL5_15 BL4_15 BL3_15 BL2_15 BL1_15 BL0_15 BL0_16 BL1_16
+  BL2_16 BL3_16 BL4_16 BL5_16 BL6_16 BL7_16 BL7_17 BL6_17 BL5_17 BL4_17
+  BL3_17 BL2_17 BL1_17 BL0_17 BL0_18 BL1_18 BL2_18 BL3_18 BL4_18 BL5_18
+  BL6_18 BL7_18 BL7_19 BL6_19 BL5_19 BL4_19 BL3_19 BL2_19 BL1_19 BL0_19
+  BL0_20 BL1_20 BL2_20 BL3_20 BL4_20 BL5_20 BL6_20 BL7_20 BL7_21 BL6_21
+  BL5_21 BL4_21 BL3_21 BL2_21 BL1_21 BL0_21 BL0_22 BL1_22 BL2_22 BL3_22
+  BL4_22 BL5_22 BL6_22 BL7_22 BL7_23 BL6_23 BL5_23 BL4_23 BL3_23 BL2_23
+  BL1_23 BL0_23 BL0_24 BL1_24 BL2_24 BL3_24 BL4_24 BL5_24 BL6_24 BL7_24
+  BL7_25 BL6_25 BL5_25 BL4_25 BL3_25 BL2_25 BL1_25 BL0_25 BL0_26 BL1_26
+  BL2_26 BL3_26 BL4_26 BL5_26 BL6_26 BL7_26 BL7_27 BL6_27 BL5_27 BL4_27
+  BL3_27 BL2_27 BL1_27 BL0_27 BL0_28 BL1_28 BL2_28 BL3_28 BL4_28 BL5_28
+  BL6_28 BL7_28 BL7_29 BL6_29 BL5_29 BL4_29 BL3_29 BL2_29 BL1_29 BL0_29
+  BL0_30 BL1_30 BL2_30 BL3_30 BL4_30 BL5_30 BL6_30 BL7_30 BL7_31 BL6_31
+  BL5_31 BL4_31 BL3_31 BL2_31 BL1_31 BL0_31 BL0__0 BL1__0 BL2__0 BL3__0
+  BL4__0 BL5__0 BL6__0 BL7__0 BL7__1 BL6__1 BL5__1 BL4__1 BL3__1 BL2__1
+  BL1__1 BL0__1 BL0__2 BL1__2 BL2__2 BL3__2 BL4__2 BL5__2 BL6__2 BL7__2
+  BL7__3 BL6__3 BL5__3 BL4__3 BL3__3 BL2__3 BL1__3 BL0__3 BL0__4 BL1__4
+  BL2__4 BL3__4 BL4__4 BL5__4 BL6__4 BL7__4 BL7__5 BL6__5 BL5__5 BL4__5
+  BL3__5 BL2__5 BL1__5 BL0__5 BL0__6 BL1__6 BL2__6 BL3__6 BL4__6 BL5__6
+  BL6__6 BL7__6 BL7__7 BL6__7 BL5__7 BL4__7 BL3__7 BL2__7 BL1__7 BL0__7
+  BL0__8 BL1__8 BL2__8 BL3__8 BL4__8 BL5__8 BL6__8 BL7__8 BL7__9 BL6__9
+  BL5__9 BL4__9 BL3__9 BL2__9 BL1__9 BL0__9 BL0__10 BL1__10 BL2__10 BL3__10
+  BL4__10 BL5__10 BL6__10 BL7__10 BL7__11 BL6__11 BL5__11 BL4__11 BL3__11
+  BL2__11 BL1__11 BL0__11 BL0__12 BL1__12 BL2__12 BL3__12 BL4__12 BL5__12
+  BL6__12 BL7__12 BL7__13 BL6__13 BL5__13 BL4__13 BL3__13 BL2__13 BL1__13
+  BL0__13 BL0__14 BL1__14 BL2__14 BL3__14 BL4__14 BL5__14 BL6__14 BL7__14
+  BL7__15 BL6__15 BL5__15 BL4__15 BL3__15 BL2__15 BL1__15 BL0__15 BL0__16
+  BL1__16 BL2__16 BL3__16 BL4__16 BL5__16 BL6__16 BL7__16 BL7__17 BL6__17
+  BL5__17 BL4__17 BL3__17 BL2__17 BL1__17 BL0__17 BL0__18 BL1__18 BL2__18
+  BL3__18 BL4__18 BL5__18 BL6__18 BL7__18 BL7__19 BL6__19 BL5__19 BL4__19
+  BL3__19 BL2__19 BL1__19 BL0__19 BL0__20 BL1__20 BL2__20 BL3__20 BL4__20
+  BL5__20 BL6__20 BL7__20 BL7__21 BL6__21 BL5__21 BL4__21 BL3__21 BL2__21
+  BL1__21 BL0__21 BL0__22 BL1__22 BL2__22 BL3__22 BL4__22 BL5__22 BL6__22
+  BL7__22 BL7__23 BL6__23 BL5__23 BL4__23 BL3__23 BL2__23 BL1__23 BL0__23
+  BL0__24 BL1__24 BL2__24 BL3__24 BL4__24 BL5__24 BL6__24 BL7__24 BL7__25
+  BL6__25 BL5__25 BL4__25 BL3__25 BL2__25 BL1__25 BL0__25 BL0__26 BL1__26
+  BL2__26 BL3__26 BL4__26 BL5__26 BL6__26 BL7__26 BL7__27 BL6__27 BL5__27
+  BL4__27 BL3__27 BL2__27 BL1__27 BL0__27 BL0__28 BL1__28 BL2__28 BL3__28
+  BL4__28 BL5__28 BL6__28 BL7__28 BL7__29 BL6__29 BL5__29 BL4__29 BL3__29
+  BL2__29 BL1__29 BL0__29 BL0__30 BL1__30 BL2__30 BL3__30 BL4__30 BL5__30
+  BL6__30 BL7__30 BL7__31 BL6__31 BL5__31 BL4__31 BL3__31 BL2__31 BL1__31
+  BL0__31 BS0_TERM BS1_TERM BTP0 BTP1 VSSE VSSE TIEHIGH TIEHIGH GDL_0 GDL_1
+  GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL__0 GDL__1
+  GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11
+  GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20
+  GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29
+  GDL__30 GDL__31 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE GTP TL0_TERM_1 GTPDST TL0_TERM_1
+  LGWEN MBL_TERM_0 MBL_TERM_1 VSSE VSSE MGTPS MWLLATE RDTN RET_15 RRBTP VSSE
+  RRENDD VSSE RXP0 VSSE RXP1 VSSE RXP2 VSSE RXP3 TIELOW_0 TL0_TERM_0 TIELOW_1
+  WBTDD XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
+  lut_sram_1024x16BH1024X16M16
XIOROW AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N AI9N AI10N AI11N AI12N
+  AI13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0_TERM BS1_TERM
+  BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9
+  BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 CEI CLK CREN CREN CREN CREN
+  CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN
+  CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN CREN DNI_0
+  DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12
+  DNI_13 DNI_14 DNI_15 EMA0 EMA1 EMA2 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26
+  GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4
+  GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14
+  GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21 GDL__22 GDL__23
+  GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30 GDL__31 GTP GTPDST
+  GTPDST RET_15 RETN_TERM_15 LGWEN TL0_TERM_0 TL0_TERM_0 TL0_TERM_0
+  TL0_TERM_0 MBL_TERM_1 TL0_TERM_1 TL0_TERM_1 MGTPS MWLLATE AI11 AI11 Q__0
+  Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14
+  Q__15 RDTN RETN RRENDD RXP0 RXP1 RXP2 RXP3 AI11 TL0_TERM_0 CREN CREN AI11
+  AI11 AI11 TL0_TERM_1 WBTDD WEI VSSE VDDPE VDDCE lut_sram_1024x16BR16IO8_1B
.ENDS lut_sram_1024x16F1024X16M16
****
.SUBCKT lut_sram_1024x16 Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7]
+  Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN WEN A[9] A[8] A[7] A[6] A[5]
+  A[4] A[3] A[2] A[1] A[0] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7]
+  D[6] D[5] D[4] D[3] D[2] D[1] D[0] EMA[2] EMA[1] EMA[0] RETN VSSE VDDPE
+  VDDCE
** lut_sram_1024x16: 114957 flat devices **
XTOP A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] A[9] AI11 CEN CLK CREN D[0]
+  D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14]
+  D[15] EMA[0] EMA[1] EMA[2] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8]
+  Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] RETN WEN VSSE VDDPE VDDCE
+  lut_sram_1024x16F1024X16M16
.ENDS lut_sram_1024x16
