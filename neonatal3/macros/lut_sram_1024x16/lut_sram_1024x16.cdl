* 
* Copyright 2026 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.4.15
* Version: r0p0-00eac0
* Name: sram_sp_hdc_svt_rvt_hvt Compiler|TSMC cln65gplus 65nm Process, 0.525um2 Bitcell
* Comment: 
* Configuration:  -instname "lut_sram_1024x16" -words 1024 -bits 16\
* Configuration:  -frequency 100 -mux 16 -pipeline off -write_mask \
* Configuration: off -wp_size 8 -write_thru on -top_layer "m5-m9" -\
* Configuration: power_type otc -redundancy off -rcols 2 -rrows 2 -\
* Configuration: bmux off -ser none -back_biasing off -power_gating\
* Configuration:  off -retention on -ema on -atf off -cust_comment \
* Configuration: "" -bus_notation on -left_bus_delim "[" -right_bus\
* Configuration: _delim "]" -pwr_gnd_rename "VDDPE:VDDPE,VDDCE:VDDC\
* Configuration: E,VSSE:VSSE" -prefix "" -name_case upper -check_in\
* Configuration: stname off -diodes on -drive 6 -dnw off -asvm on -\
* Configuration: corners ff_1p10v_1p10v_125c,tt_1p00v_1p00v_25c,ff_\
* Configuration: 1p10v_1p10v_0c,ss_0p90v_0p90v_125c,ff_1p10v_1p10v_\
* Configuration: m40c,ss_0p90v_0p90v_m40c
* Codefile: 
* 
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT lut_sram_1024x16FPIO8 BWEI BWEN CREN D DNI Q Q_ RET RETN_TERM TIEHIGH
+  TIELOW VSSE VDDPE VDDCE
** lut_sram_1024x16FPIO8: 11 flat devices **
D10 VSSE Q NDIO 1.024e-07U 1.28U $name=/D4
D7 VSSE BWEN NDIO 1.024e-07U 1.28U $name=/D7
D8 VSSE D NDIO 1.024e-07U 1.28U $name=/D6
D9 VSSE CREN NDIO 1.024e-07U 1.28U $name=/D5
M0 Q Q_ VSSE VSSE NCH W=2.8U L=0.06U M=1 $name=/qdrv/N00
M1 VDDPE Q_ Q VDDCE PCH W=4.14U L=0.06U M=1 $name=/qdrv/P00
M2 Q RET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M3 DNI D VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I238/N00
M4 VDDPE D DNI VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I238/P00
M5 BWEI BWEN VSSE VSSE NCH_HVT W=0.25U L=0.06U M=1 $name=/I237/N00
M6 VDDPE BWEN BWEI VDDCE PCH_HVT W=0.5U L=0.06U M=1 $name=/I237/P00
.ENDS lut_sram_1024x16FPIO8
****
.SUBCKT lut_sram_1024x16FLPIO8 BWEN CREN TIEHIGH TIELOW VSSE VDDPE VDDCE
** lut_sram_1024x16FLPIO8: 1 flat devices **
D0 VSSE CREN NDIO 1.024e-07U 1.28U $name=/D4
.ENDS lut_sram_1024x16FLPIO8
****
.SUBCKT lut_sram_1024x16FPIO16HP BWEI D DNI Q Q_ RET RETN_TERM TIEHIGH TIELOW
+  VSSE VDDPE VDDCE
** lut_sram_1024x16FPIO16HP: 12 flat devices **
XI0 BWEI TIELOW TIEHIGH D DNI Q Q_ RET RETN_TERM TIEHIGH TIELOW VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO8
XI1 TIELOW TIEHIGH TIEHIGH TIELOW VSSE VDDPE VDDCE lut_sram_1024x16FLPIO8
.ENDS lut_sram_1024x16FPIO16HP
****
.SUBCKT lut_sram_1024x16FPIO8RR8 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 BWEN CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 D_0
+  D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q__0 Q__1 Q__2
+  Q__3 Q__4 Q__5 Q__6 Q__7 RETN_TERM_0 RETN_TERM_1 RETN_TERM_2 RETN_TERM_3
+  RETN_TERM_4 RETN_TERM_5 RETN_TERM_6 RETN_TERM_7 RET_0 RET_1 RET_2 RET_3
+  RET_4 RET_5 RET_6 RET_7 VSSE VDDPE VDDCE
** lut_sram_1024x16FPIO8RR8: 96 flat devices **
XRIGHTIO0 BWEI_0 D_0 DNI_0 Q_0 Q__0 RET_0 RETN_TERM_0 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XRIGHTIO1 BWEI_1 D_1 DNI_1 Q_1 Q__1 RET_1 RETN_TERM_1 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XRIGHTIO2 BWEI_2 D_2 DNI_2 Q_2 Q__2 RET_2 RETN_TERM_2 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XRIGHTIO3 BWEI_3 D_3 DNI_3 Q_3 Q__3 RET_3 RETN_TERM_3 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XRIGHTIO4 BWEI_4 D_4 DNI_4 Q_4 Q__4 RET_4 RETN_TERM_4 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XRIGHTIO5 BWEI_5 D_5 DNI_5 Q_5 Q__5 RET_5 RETN_TERM_5 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XRIGHTIO6 BWEI_6 D_6 DNI_6 Q_6 Q__6 RET_6 RETN_TERM_6 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XRIGHTIOEXT7 BWEI_7 D_7 DNI_7 Q_7 Q__7 RET_7 RETN_TERM_7 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
.ENDS lut_sram_1024x16FPIO8RR8
****
.SUBCKT lut_sram_1024x16FPAL_CTRL AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4 AI4N
+  AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12
+  AI12N AI13 AI13N BWEN CEI CEN CLK EMA0 EMA1 EMA2 IRET IRETN RDT RETN STOV
+  TIEHIGH TIELOW WBT WEI WEN VSSE VDDPE VDDCE
** lut_sram_1024x16FPAL_CTRL: 54 flat devices **
D10 VSSE CLK NDIO 1.024e-07U 1.28U $name=/I2449/D1
D11 VSSE CEN NDIO 1.024e-07U 1.28U $name=/I2449/D0
D4 VSSE STOV NDIO 1.024e-07U 1.28U $name=/I2449/D7
D40 VSSE AI5 NDIO 1.024e-07U 1.28U $name=/I2450/D9
D41 VSSE AI4 NDIO 1.024e-07U 1.28U $name=/I2450/D8
D42 VSSE AI6 NDIO 1.024e-07U 1.28U $name=/I2450/D7
D43 VSSE AI7 NDIO 1.024e-07U 1.28U $name=/I2450/D6
D44 VSSE AI9 NDIO 1.024e-07U 1.28U $name=/I2450/D5
D45 VSSE AI8 NDIO 1.024e-07U 1.28U $name=/I2450/D4
D46 VSSE AI10 NDIO 1.024e-07U 1.28U $name=/I2450/D3
D47 VSSE AI11 NDIO 1.024e-07U 1.28U $name=/I2450/D2
D48 VSSE AI1 NDIO 1.024e-07U 1.28U $name=/I2450/D13
D49 VSSE AI0 NDIO 1.024e-07U 1.28U $name=/I2450/D12
D5 VSSE EMA0 NDIO 1.024e-07U 1.28U $name=/I2449/D6
D50 VSSE AI2 NDIO 1.024e-07U 1.28U $name=/I2450/D11
D51 VSSE AI3 NDIO 1.024e-07U 1.28U $name=/I2450/D10
D52 VSSE AI12 NDIO 1.024e-07U 1.28U $name=/I2450/D1
D53 VSSE AI13 NDIO 1.024e-07U 1.28U $name=/I2450/D0
D6 VSSE RETN NDIO 1.024e-07U 1.28U $name=/I2449/D3
D7 VSSE WEN NDIO 1.024e-07U 1.28U $name=/I2449/D2
D8 VSSE WBT NDIO 1.024e-07U 1.28U $name=/I2449/D12
D9 VSSE RDT NDIO 1.024e-07U 1.28U $name=/I2449/D11
M0 WEI WEN VSSE VSSE NCH W=1.68U L=0.06U M=1 $name=/I2449/tnorwece/N00
M1 VDDPE WEN WEI VDDCE PCH W=2.3U L=0.06U M=1 $name=/I2449/tnorwece/P00
M12 AI7N AI7 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I9/N00
M13 VDDPE AI7 AI7N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I9/P00
M14 AI6N AI6 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I8/N00
M15 VDDPE AI6 AI6N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I8/P00
M16 AI5N AI5 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I7/N00
M17 VDDPE AI5 AI5N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I7/P00
M18 AI0N AI0 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I60/N00
M19 VDDPE AI0 AI0N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I60/P00
M2 CEI CEN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I2449/tceninv/N00
M20 AI2N AI2 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I4/N00
M21 VDDPE AI2 AI2N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I4/P00
M22 AI1N AI1 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I3/N00
M23 VDDPE AI1 AI1N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I3/P00
M24 AI13N AI13 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I15/N00
M25 VDDPE AI13 AI13N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I15/P00
M26 AI12N AI12 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I14/N00
M27 VDDPE AI12 AI12N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I14/P00
M28 AI11N AI11 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I13/N00
M29 VDDPE AI11 AI11N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I13/P00
M3 VDDPE CEN CEI VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2449/tceninv/P00
M30 AI10N AI10 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I12/N00
M31 VDDPE AI10 AI10N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I12/P00
M32 AI9N AI9 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I11/N00
M33 VDDPE AI9 AI9N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I11/P00
M34 AI8N AI8 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I10/N00
M35 VDDPE AI8 AI8N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I10/P00
M36 AI3N AI3 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I1/N00
M37 VDDPE AI3 AI3N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I1/P00
M38 AI4N AI4 VSSE VSSE NCH W=1.12U L=0.06U M=1 $name=/I2450/I0/N00
M39 VDDPE AI4 AI4N VDDCE PCH W=2.24U L=0.06U M=1 $name=/I2450/I0/P00
.ENDS lut_sram_1024x16FPAL_CTRL
****
.SUBCKT lut_sram_1024x16FPBCTRL16M16 AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4N
+  AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11N AI12N AI13N
+  CEI CEN CLK EMA0 EMA1 EMA2 IRET IRETN RETN TIEHIGH TIELOW WEI WEN VSSE
+  VDDPE VDDCE
** lut_sram_1024x16FPBCTRL16M16: 54 flat devices **
XINSTCTRL AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N TIELOW AI4N AI5 AI5N AI6 AI6N
+  AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N TIELOW AI11N TIELOW AI12N TIELOW
+  AI13N TIELOW CEI CEN CLK EMA0 EMA1 EMA2 IRET IRETN TIELOW RETN TIELOW
+  TIEHIGH TIELOW TIELOW WEI WEN VSSE VDDPE VDDCE lut_sram_1024x16FPAL_CTRL
.ENDS lut_sram_1024x16FPBCTRL16M16
****
.SUBCKT lut_sram_1024x16FPIO8RL8 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 BWEN CREN DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 D_0
+  D_1 D_2 D_3 D_4 D_5 D_6 D_7 Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q__0 Q__1 Q__2
+  Q__3 Q__4 Q__5 Q__6 Q__7 RETN_TERM_0 RETN_TERM_1 RETN_TERM_2 RETN_TERM_3
+  RETN_TERM_4 RETN_TERM_5 RETN_TERM_6 RETN_TERM_7 RET_0 RET_1 RET_2 RET_3
+  RET_4 RET_5 RET_6 RET_7 VSSE VDDPE VDDCE
** lut_sram_1024x16FPIO8RL8: 96 flat devices **
XLEFTIO0 BWEI_0 D_0 DNI_0 Q_0 Q__0 RET_0 RETN_TERM_0 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XLEFTIO1 BWEI_1 D_1 DNI_1 Q_1 Q__1 RET_1 RETN_TERM_1 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XLEFTIO2 BWEI_2 D_2 DNI_2 Q_2 Q__2 RET_2 RETN_TERM_2 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XLEFTIO3 BWEI_3 D_3 DNI_3 Q_3 Q__3 RET_3 RETN_TERM_3 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XLEFTIO4 BWEI_4 D_4 DNI_4 Q_4 Q__4 RET_4 RETN_TERM_4 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XLEFTIO5 BWEI_5 D_5 DNI_5 Q_5 Q__5 RET_5 RETN_TERM_5 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XLEFTIO6 BWEI_6 D_6 DNI_6 Q_6 Q__6 RET_6 RETN_TERM_6 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
XLEFTIOEXT7 BWEI_7 D_7 DNI_7 Q_7 Q__7 RET_7 RETN_TERM_7 CREN BWEN VSSE VDDPE
+  VDDCE lut_sram_1024x16FPIO16HP
.ENDS lut_sram_1024x16FPIO8RL8
****
.SUBCKT lut_sram_1024x16BR16FPIO8 AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4N AI5
+  AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11N AI12N AI13N
+  BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9
+  BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 CEI CEN CLK CREN DNI_0
+  DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9 DNI_10 DNI_11 DNI_12
+  DNI_13 DNI_14 DNI_15 D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12
+  D_13 D_14 D_15 EMA0 EMA1 EMA2 IRET IRETN Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7
+  Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6
+  Q__7 Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 RETN RETN_TERM_0
+  RETN_TERM_1 RETN_TERM_2 RETN_TERM_3 RETN_TERM_4 RETN_TERM_5 RETN_TERM_6
+  RETN_TERM_7 RETN_TERM_8 RETN_TERM_9 RETN_TERM_10 RETN_TERM_11 RETN_TERM_12
+  RETN_TERM_13 RETN_TERM_14 RETN_TERM_15 RET_0 RET_1 RET_2 RET_3 RET_4 RET_5
+  RET_6 RET_7 RET_8 RET_9 RET_10 RET_11 RET_12 RET_13 RET_14 RET_15 TIELOW
+  WEI WEN VSSE VDDPE VDDCE
** lut_sram_1024x16BR16FPIO8: 246 flat devices **
XBOTCTRL AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4N AI5 AI5N AI6 AI6N AI7 AI7N
+  AI8 AI8N AI9 AI9N AI10 AI10N AI11N AI12N AI13N CEI CEN CLK EMA0 EMA1 EMA2
+  IRET IRETN RETN CREN TIELOW WEI WEN VSSE VDDPE VDDCE
+  lut_sram_1024x16FPBCTRL16M16
XLEFTIOROW BWEI_7 BWEI_6 BWEI_5 BWEI_4 BWEI_3 BWEI_2 BWEI_1 BWEI_0 TIELOW CREN
+  DNI_7 DNI_6 DNI_5 DNI_4 DNI_3 DNI_2 DNI_1 DNI_0 D_7 D_6 D_5 D_4 D_3 D_2 D_1
+  D_0 Q_7 Q_6 Q_5 Q_4 Q_3 Q_2 Q_1 Q_0 Q__7 Q__6 Q__5 Q__4 Q__3 Q__2 Q__1 Q__0
+  RETN_TERM_7 RETN_TERM_6 RETN_TERM_5 RETN_TERM_4 RETN_TERM_3 RETN_TERM_2
+  RETN_TERM_1 RETN_TERM_0 RET_7 RET_6 RET_5 RET_4 RET_3 RET_2 RET_1 RET_0
+  VSSE VDDPE VDDCE lut_sram_1024x16FPIO8RL8
XRIGHTIOROW BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15
+  TIELOW CREN DNI_8 DNI_9 DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 D_8 D_9
+  D_10 D_11 D_12 D_13 D_14 D_15 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 Q_15 Q__8
+  Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 RETN_TERM_8 RETN_TERM_9
+  RETN_TERM_10 RETN_TERM_11 RETN_TERM_12 RETN_TERM_13 RETN_TERM_14
+  RETN_TERM_15 RET_8 RET_9 RET_10 RET_11 RET_12 RET_13 RET_14 RET_15 VSSE
+  VDDPE VDDCE lut_sram_1024x16FPIO8RR8
.ENDS lut_sram_1024x16BR16FPIO8
****
.SUBCKT lut_sram_1024x16IO8_1B BWEI CE_WE CREN CRENA CRENB CRENI DNI FIOGTP
+  GDL GDLA GDLA_ GDLB GDLB_ GDLI GDLI_ GDL_ IODL IODL_ IOGTP IRET IRETN Q_
+  RDEN TIEHIGH TIELOW WE WEA WEB WEI YI YP1_0 YP1_1 YP1_2 YP1_3 YSN YSNA YSNB
+  YSNI VSSE VDDPE VDDCE
** lut_sram_1024x16IO8_1B: 172 flat devices **
M0 NET303 NET69 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tiginvpredrv/N10
M1 NET303 RDEN VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tiginvpredrv/N00
M10 VDDPE NET343 NET207 VDDCE PCH W=0.83U L=0.06U M=1 $name=/tiogdlprech/P10
M100 NET280 NET138 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/N43/N00
M101 NET114 NET92 WE VSSE NCH W=1U L=0.06U M=1 $name=/N4/N00
M102 VSSE NET280 IODL_ VSSE NCH W=3U L=0.06U M=1 $name=/N38/N00
M103 GDL NET267 IODL VSSE NCH W=3U L=0.06U M=1 $name=/N3/N00
M104 IODL NET270 GDLI VSSE NCH W=3U L=0.06U M=1 $name=/N2/N00
M105 NET275 QIE_N VSSE VSSE NCH W=2.17U L=0.06U M=1 $name=/N17/N00
M106 IODW WE NET277 VSSE NCH W=1.5U L=0.06U M=1 $name=/N12/N00
M107 IODW WE NET280 VSSE NCH W=1.5U L=0.06U M=1 $name=/N11/N00
M108 IODL_ NET267 GDL_ VSSE NCH W=3U L=0.06U M=1 $name=/N10/N00
M109 IODL_ NET270 GDLI_ VSSE NCH W=3U L=0.06U M=1 $name=/N0/N00
M11 VDDPE IOGTPD NET207 VDDCE PCH W=0.83U L=0.06U M=1 $name=/tiogdlprech/P00
M110 HNET355 CREN VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I244/N01
M111 NET289 CRENI HNET355 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I244/N00
M112 VDDPE CREN NET289 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I244/P10
M113 VDDPE CRENI NET289 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I244/P00
M114 YILOUT NET0351 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I3/N00
M115 VDDPE NET0351 YILOUT VDDCE PCH W=0.3U L=0.06U M=1 $name=/I3/P00
M116 NET0561 YI VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M117 VDDPE YI NET0561 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I1/P00
M118 WE WELOUTN VSSE VSSE NCH W=2U L=0.06U M=1 $name=/weidrv/N00
M119 VDDPE WELOUTN WE VDDCE PCH W=4U L=0.06U M=1 $name=/weidrv/P00
M12 HNET127 NET319 VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpnd2/N01
M120 NET293 BWEI VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tweinv/N00
M121 VDDPE BWEI NET293 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tweinv/P00
M122 NET295 IODL_ VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/tqbpu2drv/N00
M123 VDDPE IODL_ NET295 VDDCE PCH W=0.7U L=0.06U M=1 $name=/tqbpu2drv/P00
M124 QILAT Q_ VSSE VSSE NCH W=0.24U L=0.06U M=1 $name=/tqbfbinv/N00
M125 VDDPE Q_ QILAT VDDCE PCH W=0.47U L=0.06U M=1 $name=/tqbfbinv/P00
M126 QIE_N QIE_P VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/tlinv/N00
M127 VDDPE QIE_P QIE_N VDDCE PCH W=0.49U L=0.06U M=1 $name=/tlinv/P00
M128 QIE_P NET303 VSSE VSSE NCH W=0.62U L=0.06U M=1 $name=/tiginv/N00
M129 VDDPE NET303 QIE_P VDDCE PCH W=1.2U L=0.06U M=1 $name=/tiginv/P00
M13 IOGTPD QIE_P HNET127 VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpnd2/N00
M130 NET307 IOGTPD VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/tgtpn/N00
M131 VDDPE IOGTPD NET307 VDDCE PCH W=0.56U L=0.06U M=1 $name=/tgtpn/P00
M132 NET342 NET347 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tdinv/N00
M133 VDDPE NET347 NET342 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tdinv/P00
M134 NET311 DNI VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tdininv/N00
M135 VDDPE DNI NET311 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tdininv/P00
M136 YSEL YSN VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/gyselinv/N00
M137 VDDPE YSN YSEL VDDCE PCH W=0.6U L=0.06U M=1 $name=/gyselinv/P00
M138 WELOUTN WELOUT VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gwelat/N00
M139 VDDPE WELOUT WELOUTN VDDCE PCH W=1.4U L=0.06U M=1 $name=/gwelat/P00
M14 VDDPE NET319 IOGTPD VDDCE PCH W=0.74U L=0.06U M=1 $name=/tgtpnd2/P10
M140 WEIN NET60 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gwdly/N00
M141 VDDPE NET60 WEIN VDDCE PCH W=0.82U L=0.06U M=1 $name=/gwdly/P00
M142 NET319 IOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gtp/N00
M143 VDDPE IOGTP NET319 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gtp/P00
M144 NET270 NET78 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpginv/N00
M145 VDDPE NET78 NET270 VDDCE PCH W=1U L=0.06U M=1 $name=/gpginv/P00
M146 YSN YILOUT VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpgdrv2/N00
M147 VDDPE YILOUT YSN VDDCE PCH W=1U L=0.06U M=1 $name=/gpgdrv2/P00
M148 NET325 NET127 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gpgdrv1/N00
M149 VDDPE NET127 NET325 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gpgdrv1/P00
M15 VDDPE QIE_P IOGTPD VDDCE PCH W=0.74U L=0.06U M=1 $name=/tgtpnd2/P00
M150 NET267 NET75 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gnreg/N00
M151 VDDPE NET75 NET267 VDDCE PCH W=1U L=0.06U M=1 $name=/gnreg/P00
M152 NET138 WE VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/geninv/N00
M153 VDDPE WE NET138 VDDCE PCH W=2.8U L=0.06U M=1 $name=/geninv/P00
M154 IODW DLOUTN VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gdndrv/N00
M155 VDDPE DLOUTN IODW VDDCE PCH W=2U L=0.06U M=1 $name=/gdndrv/P00
M156 DLOUTN DLOUT VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gdlat/N00
M157 VDDPE DLOUT DLOUTN VDDCE PCH W=1.97U L=0.06U M=1 $name=/gdlat/P00
M158 NET335 DLOUTN VSSE VSSE NCH W=0.58U L=0.06U M=1 $name=/gddrvb/N00
M159 VDDPE DLOUTN NET335 VDDCE PCH W=1.14U L=0.06U M=1 $name=/gddrvb/P00
M16 HNET131 IOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N01
M160 IODW_ NET335 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gddrv/N00
M161 VDDPE NET335 IODW_ VDDCE PCH W=2U L=0.06U M=1 $name=/gddrv/P00
M162 DIN NET341 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gddly2/N00
M163 VDDPE NET341 DIN VDDCE PCH W=1U L=0.06U M=1 $name=/gddly2/P00
M164 NET341 NET342 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/gddly/N00
M165 VDDPE NET342 NET341 VDDCE PCH W=0.33U L=0.06U M=1 $name=/gddly/P00
M166 NET343 FIOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I34/N00
M167 VDDPE FIOGTP NET343 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I34/P00
M168 NET345 NET293 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I12/N00
M169 VDDPE NET293 NET345 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I12/P00
M17 NET69 NET343 HNET131 VSSE NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N00
M170 NET347 NET311 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I10/N00
M171 VDDPE NET311 NET347 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I10/P00
M18 VDDPE IOGTP NET69 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P10
M19 VDDPE NET343 NET69 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P00
M2 VDDPE NET69 HNET112 VDDCE PCH W=0.4U L=0.06U M=1 $name=/tiginvpredrv/P01
M20 HNET135 NET114 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gweio/N01
M21 NET72 NET325 HNET135 VSSE NCH W=1U L=0.06U M=1 $name=/gweio/N00
M22 VDDPE NET114 NET72 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gweio/P10
M23 VDDPE NET325 NET72 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gweio/P00
M24 HNET139 NET92 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gpreg/N01
M25 NET75 YSEL HNET139 VSSE NCH W=1U L=0.06U M=1 $name=/gpreg/N00
M26 VDDPE NET92 NET75 VDDCE PCH W=1U L=0.06U M=1 $name=/gpreg/P10
M27 VDDPE YSEL NET75 VDDCE PCH W=1U L=0.06U M=1 $name=/gpreg/P00
M28 HNET143 NET94 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gpnand/N01
M29 NET78 YSEL HNET143 VSSE NCH W=1U L=0.06U M=1 $name=/gpnand/N00
M3 HNET112 RDEN NET303 VDDCE PCH W=0.4U L=0.06U M=1 $name=/tiginvpredrv/P00
M30 VDDPE NET94 NET78 VDDCE PCH W=1U L=0.06U M=1 $name=/gpnand/P10
M31 VDDPE YSEL NET78 VDDCE PCH W=1U L=0.06U M=1 $name=/gpnand/P00
M32 HNET150 YILOUT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I2/NI00
M33 NET0351 IOGTPD HNET150 VSSE NCH W=0.15U L=0.06U M=1 $name=/I2/NE00
M34 HNET145 NET307 NET0351 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2/PE00
M35 VDDPE YILOUT HNET145 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2/PI00
M36 HNET156 WELOUTN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gwelatfb/NI00
M37 WELOUT IOGTPD HNET156 VSSE NCH W=0.15U L=0.06U M=1 $name=/gwelatfb/NE00
M38 HNET151 NET307 WELOUT VDDCE PCH W=0.15U L=0.06U M=1 $name=/gwelatfb/PE00
M39 VDDPE WELOUTN HNET151 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gwelatfb/PI00
M4 HNET119 NET345 VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/wnand/N01
M40 HNET162 DLOUTN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NI00
M41 DLOUT IOGTPD HNET162 VSSE NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NE00
M42 HNET157 NET307 DLOUT VDDCE PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PE00
M43 VDDPE DLOUTN HNET157 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PI00
M44 NET92 NET289 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/tcrend/N00
M45 VDDPE NET289 NET92 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/tcrend/P00
M46 NET94 NET92 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gcrendd/N00
M47 VDDPE NET92 NET94 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gcrendd/P00
M48 Q_ IRETN VDDPE VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/tqbpuretn/P00
M49 NET103 QILAT Q_ VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/tqbpu2/P00
M5 NET60 CE_WE HNET119 VSSE NCH W=0.25U L=0.06U M=1 $name=/wnand/N00
M50 VDDPE QIE_N NET103 VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/P35/P00
M51 VDDPE NET295 NET103 VDDCE PCH_HVT W=1.06U L=0.06U M=1 $name=/P33/P00
M52 WELOUT IOGTPD WEIN VDDCE PCH W=0.49U L=0.06U M=1 $name=/wpgp/P00
M53 NET113 IODL Q_ VDDCE PCH W=2.13U L=0.06U M=1 $name=/tqbpu/P00
M54 VDDPE NET114 NET149 VDDCE PCH W=1U L=0.06U M=1 $name=/tpswitch/P00
M55 VDDPE NET207 GDLPRE VDDCE PCH W=1.5U L=0.06U M=1 $name=/tppreb/P00
M56 VDDPE NET72 GDLPRE VDDCE PCH W=1.5U L=0.06U M=1 $name=/tpprea/P00
M57 YSN NET94 NET127 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tppg2/P00
M58 YSNI NET92 NET127 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tppg1/P00
M59 NET0351 IOGTPD NET0561 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tpgp2/P00
M6 VDDPE NET345 NET60 VDDCE PCH W=0.25U L=0.06U M=1 $name=/wnand/P10
M60 DLOUT IOGTPD DIN VDDCE PCH W=0.49U L=0.06U M=1 $name=/tpdpass/P00
M61 VDDPE WE NET136 VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlpukp/P00
M62 NET136 NET138 IODW_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdlppgp/P00
M63 VDDPE GDLPRE GDL VDDCE PCH W=3U L=0.06U M=1 $name=/tgdlpch/P00
M64 NET248 NET138 IODW_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdlnpgp/P00
M65 NET149 GDL_ GDL VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlkeeperio/P00
M66 GDL GDLPRE GDL_ VDDCE PCH W=3U L=0.06U M=1 $name=/tgdleq/P00
M67 IODL NET136 VDDPE VDDCE PCH W=5U L=0.06U M=1 $name=/tgdldrvp/P00
M68 NET149 GDL GDL_ VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlbkeeper/P00
M69 NET280 NET138 IODW VDDCE PCH W=1.5U L=0.06U M=1 $name=/P7/P00
M7 VDDPE CE_WE NET60 VDDCE PCH W=0.25U L=0.06U M=1 $name=/wnand/P00
M70 WEI NET92 NET114 VDDCE PCH W=1U L=0.06U M=1 $name=/P6/P00
M71 VDDPE WE NET277 VDDCE PCH W=1U L=0.06U M=1 $name=/P55/P00
M72 WE NET94 NET114 VDDCE PCH W=1U L=0.06U M=1 $name=/P5/P00
M73 IODL_ NET277 VDDPE VDDCE PCH W=5U L=0.06U M=1 $name=/P43/P00
M74 GDL_ NET75 IODL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P4/P00
M75 IODL NET75 GDL VDDCE PCH W=3U L=0.06U M=1 $name=/P3/P00
M76 VDDPE GDLPRE GDL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P2/P00
M77 VDDPE QIE_P NET194 VDDCE PCH W=2.13U L=0.06U M=1 $name=/P18/P00
M78 VDDPE QIE_P NET113 VDDCE PCH W=2.13U L=0.06U M=1 $name=/P13/P00
M79 NET277 NET138 IODW VDDCE PCH W=1.5U L=0.06U M=1 $name=/P12/P00
M8 HNET123 NET343 VSSE VSSE NCH W=0.84U L=0.06U M=1 $name=/tiogdlprech/N01
M80 NET194 IODL Q_ VDDCE PCH W=2.13U L=0.06U M=1 $name=/P11/P00
M81 GDLI NET78 IODL VDDCE PCH W=3U L=0.06U M=1 $name=/P1/P00
M82 GDLI_ NET78 IODL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P0/P00
M83 VSSE IRETN NET220 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/tqbpdretn/N00
M84 Q_ QILAT NET221 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/tqbpd2/N00
M85 NET221 QIE_P NET220 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/N20/N00
M86 NET221 IODL NET220 VSSE NCH_HVT W=1U L=0.06U M=1 $name=/N18/N00
M87 WEIN NET307 WELOUT VSSE NCH W=0.5U L=0.06U M=1 $name=/wpgn/N00
M88 Q_ NET295 NET275 VSSE NCH W=2.17U L=0.06U M=1 $name=/tqbpd/N00
M89 NET0561 NET307 NET0351 VSSE NCH W=0.2U L=0.06U M=1 $name=/tpgn2/N00
M9 NET207 IOGTPD HNET123 VSSE NCH W=0.84U L=0.06U M=1 $name=/tiogdlprech/N00
M90 NET209 NET207 VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/tnpreb/N00
M91 GDLPRE NET72 NET209 VSSE NCH W=1.5U L=0.06U M=1 $name=/tnprea/N00
M92 NET127 NET92 YSN VSSE NCH W=0.2U L=0.06U M=1 $name=/tnpg2/N00
M93 NET127 NET94 YSNI VSSE NCH W=0.2U L=0.06U M=1 $name=/tnpg1/N00
M94 DIN NET307 DLOUT VSSE NCH W=0.5U L=0.06U M=1 $name=/tndpass/N00
M95 IODW_ WE NET136 VSSE NCH W=1.5U L=0.06U M=1 $name=/tgdlppgn/N00
M96 NET248 NET138 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/tgdlpdkp/N00
M97 IODW_ WE NET248 VSSE NCH W=1.5U L=0.06U M=1 $name=/tgdlnpgn/N00
M98 VSSE NET248 IODL VSSE NCH W=3U L=0.06U M=1 $name=/tgdldrvn/N00
M99 NET114 NET94 WEI VSSE NCH W=1U L=0.06U M=1 $name=/N9/N00
.ENDS lut_sram_1024x16IO8_1B
****
.SUBCKT lut_sram_1024x16FLIO8_1B CE_WE CREN CRENA CRENB CRENI FIOGTP GDL GDLA
+  GDLA_ GDLB GDLB_ GDLI GDLI_ GDL_ IODL IODL_ IOGTP IRET IRETN TIEHIGH TIELOW
+  WE WEA WEB WEI YI YP1_0 YP1_1 YP1_2 YP1_3 YSN YSNA YSNB YSNI VSSE VDDPE
+  VDDCE
** lut_sram_1024x16FLIO8_1B: 90 flat devices **
M0 HNET85 YILOUT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I2/NI00
M1 NET244 IOGTPD HNET85 VSSE NCH W=0.15U L=0.06U M=1 $name=/I2/NE00
M10 VDDPE NET364 IOGTPD VDDCE PCH W=0.21U L=0.06U M=1 $name=/tgtpnd2/P10
M11 VDDPE NET367 IOGTPD VDDCE PCH W=0.21U L=0.06U M=1 $name=/tgtpnd2/P00
M12 HNET96 IOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N01
M13 NET254 NET383 HNET96 VSSE NCH W=0.15U L=0.06U M=1 $name=/tfiogtpnd2/N00
M14 VDDPE IOGTP NET254 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P10
M15 VDDPE NET383 NET254 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tfiogtpnd2/P00
M16 HNET100 NET269 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gweio/N01
M17 NET257 NET379 HNET100 VSSE NCH W=1U L=0.06U M=1 $name=/gweio/N00
M18 VDDPE NET269 NET257 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gweio/P10
M19 VDDPE NET379 NET257 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gweio/P00
M2 HNET79 NET369 NET244 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2/PE00
M20 HNET104 NET265 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gpreg/N01
M21 NET260 YSEL HNET104 VSSE NCH W=1U L=0.06U M=1 $name=/gpreg/N00
M22 VDDPE NET265 NET260 VDDCE PCH W=1U L=0.06U M=1 $name=/gpreg/P10
M23 VDDPE YSEL NET260 VDDCE PCH W=1U L=0.06U M=1 $name=/gpreg/P00
M24 HNET108 NET267 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gpnand/N01
M25 NET263 YSEL HNET108 VSSE NCH W=1U L=0.06U M=1 $name=/gpnand/N00
M26 VDDPE NET267 NET263 VDDCE PCH W=1U L=0.06U M=1 $name=/gpnand/P10
M27 VDDPE YSEL NET263 VDDCE PCH W=1U L=0.06U M=1 $name=/gpnand/P00
M28 NET265 NET266 VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/tcrend/N00
M29 VDDPE NET266 NET265 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/tcrend/P00
M3 VDDPE YILOUT HNET79 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I2/PI00
M30 NET267 NET265 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gcrendd/N00
M31 VDDPE NET265 NET267 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gcrendd/P00
M32 VDDPE NET269 NET292 VDDCE PCH W=1U L=0.06U M=1 $name=/tpswitch/P00
M33 VDDPE NET320 GDLPRE VDDCE PCH W=1.5U L=0.06U M=1 $name=/tppreb/P00
M34 VDDPE NET257 GDLPRE VDDCE PCH W=1.5U L=0.06U M=1 $name=/tpprea/P00
M35 YSN NET267 NET340 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tppg2/P00
M36 YSNI NET265 NET340 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tppg1/P00
M37 NET244 IOGTPD NET361 VDDCE PCH W=0.2U L=0.06U M=1 $name=/tpgp2/P00
M38 VDDPE GDLPRE GDL VDDCE PCH W=3U L=0.06U M=1 $name=/tgdlpch/P00
M39 NET292 GDL_ GDL VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlkeeperio/P00
M4 HNET88 NET383 VSSE VSSE NCH W=1.31U L=0.06U M=1 $name=/tiogdlprech/N01
M40 GDL GDLPRE GDL_ VDDCE PCH W=3U L=0.06U M=1 $name=/tgdleq/P00
M41 NET292 GDL GDL_ VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlbkeeper/P00
M42 WEI NET265 NET269 VDDCE PCH W=1U L=0.06U M=1 $name=/P6/P00
M43 WE NET267 NET269 VDDCE PCH W=1U L=0.06U M=1 $name=/P5/P00
M44 GDL_ NET260 IODL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P4/P00
M45 IODL NET260 GDL VDDCE PCH W=3U L=0.06U M=1 $name=/P3/P00
M46 VDDPE GDLPRE GDL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P2/P00
M47 GDLI NET263 IODL VDDCE PCH W=3U L=0.06U M=1 $name=/P1/P00
M48 GDLI_ NET263 IODL_ VDDCE PCH W=3U L=0.06U M=1 $name=/P0/P00
M49 NET361 NET369 NET244 VSSE NCH W=0.2U L=0.06U M=1 $name=/tpgn2/N00
M5 NET320 IOGTPD HNET88 VSSE NCH W=1.31U L=0.06U M=1 $name=/tiogdlprech/N00
M50 NET322 NET320 VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/tnpreb/N00
M51 GDLPRE NET257 NET322 VSSE NCH W=0.75U L=0.06U M=1 $name=/tnprea/N00
M52 NET340 NET265 YSN VSSE NCH W=0.2U L=0.06U M=1 $name=/tnpg2/N00
M53 NET340 NET267 YSNI VSSE NCH W=0.2U L=0.06U M=1 $name=/tnpg1/N00
M54 NET269 NET267 WEI VSSE NCH W=1U L=0.06U M=1 $name=/N9/N00
M55 NET328 NET320 VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/N8/N00
M56 GDLPRE NET257 NET328 VSSE NCH W=0.75U L=0.06U M=1 $name=/N7/N00
M57 NET269 NET265 WE VSSE NCH W=1U L=0.06U M=1 $name=/N4/N00
M58 GDL NET347 IODL VSSE NCH W=3U L=0.06U M=1 $name=/N3/N00
M59 IODL NET350 GDLI VSSE NCH W=3U L=0.06U M=1 $name=/N2/N00
M6 VDDPE NET383 NET320 VDDCE PCH W=0.89U L=0.06U M=1 $name=/tiogdlprech/P10
M60 IODL_ NET347 GDL_ VSSE NCH W=3U L=0.06U M=1 $name=/N10/N00
M61 IODL_ NET350 GDLI_ VSSE NCH W=3U L=0.06U M=1 $name=/N0/N00
M62 NET361 YI VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M63 VDDPE YI NET361 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I1/P00
M64 YILOUT NET244 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I3/N00
M65 VDDPE NET244 YILOUT VDDCE PCH W=0.3U L=0.06U M=1 $name=/I3/P00
M66 NET365 NET254 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiginvpredrv/N00
M67 VDDPE NET254 NET365 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tiginvpredrv/P00
M68 NET367 NET365 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiginv/N00
M69 VDDPE NET365 NET367 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tiginv/P00
M7 VDDPE IOGTPD NET320 VDDCE PCH W=0.89U L=0.06U M=1 $name=/tiogdlprech/P00
M70 NET369 IOGTPD VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tgtpn/N00
M71 VDDPE IOGTPD NET369 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tgtpn/P00
M72 YSEL YSN VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/gyselinv/N00
M73 VDDPE YSN YSEL VDDCE PCH W=0.6U L=0.06U M=1 $name=/gyselinv/P00
M74 NET364 IOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gtp/N00
M75 VDDPE IOGTP NET364 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gtp/P00
M76 NET350 NET263 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpginv/N00
M77 VDDPE NET263 NET350 VDDCE PCH W=1U L=0.06U M=1 $name=/gpginv/P00
M78 YSN YILOUT VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gpgdrv2/N00
M79 VDDPE YILOUT YSN VDDCE PCH W=1U L=0.06U M=1 $name=/gpgdrv2/P00
M8 HNET92 NET364 VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/tgtpnd2/N01
M80 NET379 NET340 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gpgdrv1/N00
M81 VDDPE NET340 NET379 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gpgdrv1/P00
M82 NET347 NET260 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gnreg/N00
M83 VDDPE NET260 NET347 VDDCE PCH W=1U L=0.06U M=1 $name=/gnreg/P00
M84 NET383 FIOGTP VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I34/N00
M85 VDDPE FIOGTP NET383 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I34/P00
M86 HNET230 CREN VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/I244/N01
M87 NET266 CRENI HNET230 VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/I244/N00
M88 VDDPE CREN NET266 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I244/P10
M89 VDDPE CRENI NET266 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I244/P00
M9 IOGTPD NET367 HNET92 VSSE NCH W=0.31U L=0.06U M=1 $name=/tgtpnd2/N00
.ENDS lut_sram_1024x16FLIO8_1B
****
.SUBCKT lut_sram_1024x16IO16HP BWEI CE_WE CRENA CREN_0 CREN_1 DNI FIOGTP GDLA
+  GDL_0 GDL_1 GDL__0 GDL__1 IOGTP IRET IRETN Q_ YP1_0 YP1_1 YP1_2 YP1_3 VSSE
+  VDDPE VDDCE
** lut_sram_1024x16IO16HP: 262 flat devices **
XI0 BWEI CE_WE CREN_0 CRENA CRENA CRENA DNI FIOGTP GDL_0 GDLA CRENA GDLA CRENA
+  GDLI GDLI_ GDL__0 IODL IODL_ IOGTP IRET IRETN Q_ GDLA CRENA GDLA WE GDLA
+  GDLA GDLA YP1_0 YP1_0 YP1_1 YP1_2 YP1_3 YSN CRENA CRENA CRENA VSSE VDDPE
+  VDDCE lut_sram_1024x16IO8_1B
XI1 CE_WE CREN_1 CRENA CRENA CRENA FIOGTP GDL_1 GDLA CRENA GDLA CRENA GDLI_8
+  GDLI__6 GDL__1 IODL IODL_ IOGTP IRET IRETN CRENA GDLA WE GDLA GDLA GDLA
+  YP1_1 YP1_0 YP1_1 YP1_2 YP1_3 YSN_10 CRENA CRENA CRENA VSSE VDDPE VDDCE
+  lut_sram_1024x16FLIO8_1B
.ENDS lut_sram_1024x16IO16HP
****
.SUBCKT lut_sram_1024x16IO8EDGE_1B CE_WE_TERM CRENA_TERM FIOGTP_TERM GDLA_TERM
+  GDLA__TERM IOGTP_TERM IRETN_TERM IRET_TERM TIEHIGH TIELOW TIELOW_TERM
+  WE_TERM YP0_TERM YP1_TERM YP2_TERM YP3_TERM YSNA_TERM VSSE VDDPE VDDCE
** lut_sram_1024x16IO8EDGE_1B: 4 flat devices **
M0 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M1 VDDPE TIELOW TIEHIGH VDDCE PCH W=4.9U L=0.06U M=1 $name=/P0/P00
M2 TIELOW TIEHIGH VSSE VSSE NCH W=3.15U L=0.06U M=1 $name=/tioarefn/N00
M3 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
.ENDS lut_sram_1024x16IO8EDGE_1B
****
.SUBCKT lut_sram_1024x16IO8_1BRR8 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 CE_WE CREN_0 CREN_1 CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7
+  CREN_8 CREN_9 CREN_10 CREN_11 CREN_12 CREN_13 CREN_14 CREN_15 DNI_0 DNI_1
+  DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 FIOGTP GDLA GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8
+  GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 IOGTP IRET IRETN
+  Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 TIEHIGH TIELOW YP1_0 YP1_1 YP1_2
+  YP1_3 VSSE VDDPE VDDCE
** lut_sram_1024x16IO8_1BRR8: 2100 flat devices **
XRIGHTIO0 BWEI_0 CE_WE TIEHIGH CREN_0 CREN_1 DNI_0 FIOGTP GDLA GDL_0 GDL_1
+  GDL__0 GDL__1 IOGTP IRET IRETN Q__0 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XRIGHTIO1 BWEI_1 CE_WE TIEHIGH CREN_2 CREN_3 DNI_1 FIOGTP GDLA GDL_2 GDL_3
+  GDL__2 GDL__3 IOGTP IRET IRETN Q__1 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XRIGHTIO2 BWEI_2 CE_WE TIEHIGH CREN_4 CREN_5 DNI_2 FIOGTP GDLA GDL_4 GDL_5
+  GDL__4 GDL__5 IOGTP IRET IRETN Q__2 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XRIGHTIO3 BWEI_3 CE_WE TIEHIGH CREN_6 CREN_7 DNI_3 FIOGTP GDLA GDL_6 GDL_7
+  GDL__6 GDL__7 IOGTP IRET IRETN Q__3 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XRIGHTIO4 BWEI_4 CE_WE TIEHIGH CREN_8 CREN_9 DNI_4 FIOGTP GDLA GDL_8 GDL_9
+  GDL__8 GDL__9 IOGTP IRET IRETN Q__4 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XRIGHTIO5 BWEI_5 CE_WE TIEHIGH CREN_10 CREN_11 DNI_5 FIOGTP GDLA GDL_10 GDL_11
+  GDL__10 GDL__11 IOGTP IRET IRETN Q__5 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XRIGHTIO6 BWEI_6 CE_WE TIEHIGH CREN_12 CREN_13 DNI_6 FIOGTP GDLA GDL_12 GDL_13
+  GDL__12 GDL__13 IOGTP IRET IRETN Q__6 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XRIGHTIOEDGE8 CE_WE TIEHIGH FIOGTP GDLA TIEHIGH IOGTP IRETN IRET TIEHIGH
+  TIELOW GDLA GDLA YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH VSSE VDDPE VDDCE
+  lut_sram_1024x16IO8EDGE_1B
XRIGHTIOEXT7 BWEI_7 CE_WE TIEHIGH CREN_14 CREN_15 DNI_7 FIOGTP GDLA GDL_14
+  GDL_15 GDL__14 GDL__15 IOGTP IRET IRETN Q__7 YP1_0 YP1_1 YP1_2 YP1_3 VSSE
+  VDDPE VDDCE lut_sram_1024x16IO16HP
.ENDS lut_sram_1024x16IO8_1BRR8
****
.SUBCKT lut_sram_1024x16CTRL_1B AGTP AGTPN AX6N AY3 AY4 BS0N BS1N CEI CE_WE
+  CLK CREN_TERM EMA0 EMA1 EMA2 FIOGTPL FIOGTPR GDLA_TERM GDLA__TERM GTP GTPDE
+  GTPDEI GTPDET GTPDS GTPDSF GTPDST IOGTPL IOGTPR IRET IRETN LGWEN MBL MGDLE
+  MGDLET MGDLS MGDLST MGTPS MWLLATE PRDT PWBT RDT RETN RRENDD STOV TIEHIGH
+  TIELOW TL0_TERM WBTDD WEI WE_TERM YP1_0 YP1_1 YP1_2 YP1_3 YSNA_TERM VSSE
+  VDDPE VDDCE
** lut_sram_1024x16CTRL_1B: 383 flat devices **
D381 VSSE EMA1 NDIO 1.024e-07U 1.28U $name=/D5
D382 VSSE EMA2 NDIO 1.024e-07U 1.28U $name=/D4
M0 HNET184 GTP VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N31
M1 DELAYEDMBL NET828 HNET184 VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N30
M10 HNET189 NET389 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N11
M100 VDDPE GTP NET581 VDDCE PCH W=0.3U L=0.12U M=1 $name=/tdlyp3a/P00
M101 VDDPE NET581 NET584 VDDCE PCH W=0.36U L=0.06U M=1 $name=/tdlyp2/P00
M102 NET0495 GTP MSI VDDCE PCH W=0.45U L=0.06U M=1 $name=/tdlyp1/P00
M103 NET798 RGWEN NET571 VDDCE PCH W=0.3U L=0.06U M=1 $name=/P8/P00
M104 VDDPE NET604 NET544 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P5/P00
M105 VDDPE GTPDEI NET0424 VDDCE PCH W=0.45U L=0.06U M=1 $name=/P4/P00
M106 VDDPE NET571 GTPDED VDDCE PCH W=0.15U L=0.06U M=1 $name=/P3/P00
M107 NET0424 RGWE NET571 VDDCE PCH W=0.3U L=0.06U M=1 $name=/P23/P00
M108 VDDPE GTP NET0495 VDDCE PCH W=0.45U L=0.12U M=1 $name=/P2/P00
M109 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M11 AGTP GTPB HNET189 VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N10
M110 VDDPE NET592 TIEHIGH VDDCE PCH W=0.9U L=0.06U M=1 $name=/P0/P00
M111 GTP IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N0/N00
M112 NET584 NET581 VSSE VSSE NCH_HVT W=0.3U L=0.12U M=1 $name=/tdlyn2a/N00
M113 EMAPRE EMA00 NET427 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/dlypassn/N00
M114 EMAPRE EMA11 NET537 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/N28/N00
M115 EMAPRE EMA10 NET707 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/N27/N00
M116 NET544 NET604 NET543 VSSE NCH_HVT W=0.45U L=0.12U M=1 $name=/N25/N00
M117 EMAPRE EMA01 NET710 VSSE NCH_HVT W=0.89U L=0.06U M=1 $name=/N24/N00
M118 GTPDS IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M119 WELOUT AGTPN WEI VSSE NCH W=0.36U L=0.06U M=1 $name=/tpgwen4/N00
M12 HNET187 NET389 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N01
M120 RGWEB AGTP NET819 VSSE NCH W=0.15U L=0.06U M=1 $name=/tpgwen3/N00
M121 NET626 AGTPN RGWEB VSSE NCH W=0.15U L=0.06U M=1 $name=/tpgwen2/N00
M122 NET565 AGTP WELOUT VSSE NCH W=0.15U L=0.06U M=1 $name=/tpgwen1/N00
M123 NET571 RGWEN NET0424 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnpggtpde/N00
M124 NET0424 GTPDEI VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/tngtpdeskew2/N00
M125 GTP SETGTP NET598 VSSE NCH W=3U L=0.06U M=1 $name=/tgtpdrvn/N00
M126 NET581 GTP VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/tdlyn3/N00
M127 VSSE NET581 VSSE VSSE NCH W=0.3U L=0.12U M=1 $name=/tdlyn2b/N00
M128 MSI GTP VSSE VSSE NCH W=1.4U L=0.06U M=1 $name=/tdlyn1/N00
M129 SETGTP A CLKB VSSE NCH W=6.78U L=0.06U M=1 $name=/tclkbn/N00
M13 AGTP GTPB HNET187 VSSE NCH W=1.75U L=0.06U M=1 $name=/I14/N00
M130 NET592 NET592 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N9/N00
M131 NET612 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N7/N00
M132 NET598 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N6/N00
M133 NET571 RGWE NET798 VSSE NCH W=0.15U L=0.06U M=1 $name=/N31/N00
M134 NET604 TIELOW VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/N30/N00
M135 NET543 NET604 VSSE VSSE NCH W=0.45U L=0.12U M=1 $name=/N26/N00
M136 GTPDED NET571 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/N22/N00
M137 NET610 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N2/N00
M138 GTP SETGTP NET612 VSSE NCH W=3U L=0.06U M=1 $name=/N18/N00
M139 GTP SETGTP NET610 VSSE NCH W=3U L=0.06U M=1 $name=/N16/N00
M14 VDDPE NET389 AGTP VDDCE PCH W=3.5U L=0.06U M=1 $name=/I14/P10
M140 GTP SETGTP NET625 VSSE NCH W=3U L=0.06U M=1 $name=/N14/N00
M141 NET592 TIEHIGH VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/N10/N00
M142 NET625 GTPB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N1/N00
M143 NET626 RGWE VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv2/N00
M144 VDDPE RGWE NET626 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv2/P00
M145 NET565 NET819 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv1/N00
M146 VDDPE NET819 NET565 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/tlatinv1/P00
M147 STOVB STOVI VSSE VSSE NCH_HVT W=0.23U L=0.06U M=1 $name=/stovsel/N00
M148 VDDPE STOVI STOVB VDDCE PCH_HVT W=0.32U L=0.06U M=1 $name=/stovsel/P00
M149 EMA00 EMA00B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/selinv/N00
M15 VDDPE GTPB AGTP VDDCE PCH W=3.5U L=0.06U M=1 $name=/I14/P00
M150 VDDPE EMA00B EMA00 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/selinv/P00
M151 NET720 EMA1N VSSE VSSE NCH_HVT W=0.22U L=0.06U M=1 $name=/sel1/N00
M152 VDDPE EMA1N NET720 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/sel1/P00
M153 NET722 EMA0N VSSE VSSE NCH_HVT W=0.22U L=0.06U M=1 $name=/sel0/N00
M154 VDDPE EMA0N NET722 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/sel0/P00
M155 MBLSELN MBLSEL VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/mblsel0/N00
M156 VDDPE MBLSEL MBLSELN VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel0/P00
M157 LONGEMA NET641 VSSE VSSE NCH_HVT W=0.25U L=0.06U M=1 $name=/longd4/N00
M158 VDDPE NET641 LONGEMA VDDCE PCH_HVT W=0.35U L=0.06U M=1 $name=/longd4/P00
M159 NET701 NET643 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/longd1/N00
M16 HNET194 DELAYEDGTP VSSE VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N11
M160 VDDPE NET643 NET701 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd1/P00
M161 NET647 MBLN VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gdlyinv2/N00
M162 VDDPE MBLN NET647 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gdlyinv2/P00
M163 NET646 NET647 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/gdlyinv1/N00
M164 VDDPE NET647 NET646 VDDCE PCH_HVT W=0.33U L=0.06U M=1 $name=/gdlyinv1/P00
M165 NET537 NET706 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv3/N00
M166 VDDPE NET706 NET537 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv3/P00
M167 NET707 NET651 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv2/N00
M168 VDDPE NET651 NET707 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv2/P00
M169 NET710 NET653 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv1/N00
M17 RESETGTP DELAYEDMBL HNET194 VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N10
M170 VDDPE NET653 NET710 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv1/P00
M171 NET427 NET655 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/dlyinv0/N00
M172 VDDPE NET655 NET427 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/dlyinv0/P00
M173 NET656 PRDT VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I99/N00
M174 VDDPE PRDT NET656 VDDCE PCH_HVT W=0.41U L=0.06U M=1 $name=/I99/P00
M175 EMA10 EMA10B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I93/N00
M176 VDDPE EMA10B EMA10 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/I93/P00
M177 EMA11 EMA11B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I92/N00
M178 VDDPE EMA11B EMA11 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/I92/P00
M179 EMA01 EMA01B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I91/N00
M18 HNET192 DELAYEDGTP VSSE VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N01
M180 VDDPE EMA01B EMA01 VDDCE PCH_HVT W=0.17U L=0.06U M=1 $name=/I91/P00
M181 EMA0N EMA0 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/I90/N00
M182 VDDPE EMA0 EMA0N VDDCE PCH_HVT W=0.56U L=0.06U M=1 $name=/I90/P00
M183 NET695 STOV VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I89/N00
M184 VDDPE STOV NET695 VDDCE PCH_HVT W=0.42U L=0.06U M=1 $name=/I89/P00
M185 EMA2N EMA2 VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I88/N00
M186 VDDPE EMA2 EMA2N VDDCE PCH_HVT W=0.58U L=0.06U M=1 $name=/I88/P00
M187 EMA1N EMA1 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/I87/N00
M188 VDDPE EMA1 EMA1N VDDCE PCH_HVT W=0.56U L=0.06U M=1 $name=/I87/P00
M189 HNET491 DELAYEDGTP VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/tsend/N01
M19 RESETGTP DELAYEDMBL HNET192 VSSE NCH W=1.17U L=0.06U M=1 $name=/trstgtpw/N00
M190 NET736 CLKB HNET491 VSSE NCH W=1.86U L=0.06U M=1 $name=/tsend/N00
M191 VDDPE DELAYEDGTP NET736 VDDCE PCH W=1.26U L=0.06U M=1 $name=/tsend/P10
M192 VDDPE CLKB NET736 VDDCE PCH W=1.26U L=0.06U M=1 $name=/tsend/P00
M193 HNET495 RESETGTP VSSE VSSE NCH W=4.62U L=0.06U M=1 $name=/tgtprsnd/N01
M194 GTPB GTP HNET495 VSSE NCH W=4.62U L=0.06U M=1 $name=/tgtprsnd/N00
M195 VDDCE RESETGTP GTPB VDDCE PCH W=3.54U L=0.06U M=1 $name=/tgtprsnd/P10
M196 VDDCE GTP GTPB VDDCE PCH W=3.54U L=0.06U M=1 $name=/tgtprsnd/P00
M197 HNET499 RGWEN VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpdnd2/N01
M198 NET683 MGDLE HNET499 VSSE NCH W=0.75U L=0.06U M=1 $name=/tgtpdnd2/N00
M199 VDDPE RGWEN NET683 VDDCE PCH W=0.51U L=0.06U M=1 $name=/tgtpdnd2/P10
M2 HNET179 GTP VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N21
M20 VDDPE DELAYEDGTP RESETGTP VDDCE PCH W=1.58U L=0.06U M=1 $name=/trstgtpw/P10
M200 VDDPE MGDLE NET683 VDDCE PCH W=0.51U L=0.06U M=1 $name=/tgtpdnd2/P00
M201 HNET503 NET683 VSSE VSSE NCH W=1.57U L=0.06U M=1 $name=/tgtpddrv3/N01
M202 NET682 NET389 HNET503 VSSE NCH W=1.57U L=0.06U M=1 $name=/tgtpddrv3/N00
M203 VDDPE NET683 NET682 VDDCE PCH W=1.07U L=0.06U M=1 $name=/tgtpddrv3/P10
M204 VDDPE NET389 NET682 VDDCE PCH W=1.07U L=0.06U M=1 $name=/tgtpddrv3/P00
M205 HNET507 AB VSSE VSSE NCH W=1.55U L=0.06U M=1 $name=/tgsetnd/N01
M206 NET807 GTPNDDW HNET507 VSSE NCH W=1.55U L=0.06U M=1 $name=/tgsetnd/N00
M207 VDDPE AB NET807 VDDCE PCH W=1.05U L=0.06U M=1 $name=/tgsetnd/P10
M208 VDDPE GTPNDDW NET807 VDDCE PCH W=1.05U L=0.06U M=1 $name=/tgsetnd/P00
M209 HNET511 CLKB VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tclkce/N01
M21 VDDPE DELAYEDMBL RESETGTP VDDCE PCH W=1.58U L=0.06U M=1 $name=/trstgtpw/P00
M210 CLKCE CEI HNET511 VSSE NCH W=0.3U L=0.06U M=1 $name=/tclkce/N00
M211 VDDPE CLKB CLKCE VDDCE PCH W=0.33U L=0.06U M=1 $name=/tclkce/P10
M212 VDDPE CEI CLKCE VDDCE PCH W=0.33U L=0.06U M=1 $name=/tclkce/P00
M213 HNET515 CLK VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tcknd/N01
M214 NET691 RETDD HNET515 VSSE NCH W=0.18U L=0.06U M=1 $name=/tcknd/N00
M215 VDDPE CLK NET691 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tcknd/P10
M216 VDDPE RETDD NET691 VDDCE PCH W=0.33U L=0.06U M=1 $name=/tcknd/P00
M217 HNET519 NET695 VSSE VSSE NCH_HVT W=1.26U L=0.06U M=1 $name=/tstovnd/N01
M218 STOVI NET656 HNET519 VSSE NCH_HVT W=1.26U L=0.06U M=1 $name=/tstovnd/N00
M219 VDDPE NET695 STOVI VDDCE PCH_HVT W=0.86U L=0.06U M=1 $name=/tstovnd/P10
M22 HNET199 AY4 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N11
M220 VDDPE NET656 STOVI VDDCE PCH_HVT W=0.86U L=0.06U M=1 $name=/tstovnd/P00
M221 HNET523 EMA0N VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/selnand/N01
M222 EMA00B EMA1N HNET523 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/selnand/N00
M223 VDDPE EMA0N EMA00B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/selnand/P10
M224 VDDPE EMA1N EMA00B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/selnand/P00
M225 HNET527 NET701 VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/longd3/N01
M226 NET641 DELAYEDGTP HNET527 VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/longd3/N00
M227 VDDPE NET701 NET641 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd3/P10
M228 VDDPE DELAYEDGTP NET641 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd3/P00
M229 HNET531 NET646 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/N01
M23 NET394 AY3 HNET199 VSSE NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N10
M230 NET643 DELAYEDGTP HNET531 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/N00
M231 VDDPE NET646 NET643 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/P10
M232 VDDPE DELAYEDGTP NET643 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/longd0/P00
M233 HNET535 NET707 VSSE VSSE NCH_HVT W=0.81U L=0.06U M=1 $name=/dlynand3/N01
M234 NET706 DELAYEDGTP HNET535 VSSE NCH_HVT W=0.81U L=0.06U M=1 $name=/dlynand3/N00
M235 VDDPE NET707 NET706 VDDCE PCH_HVT W=0.56U L=0.06U M=1 $name=/dlynand3/P10
M236 VDDPE DELAYEDGTP NET706 VDDCE PCH_HVT W=0.56U L=0.06U M=1 $name=/dlynand3/P00
M237 HNET539 NET710 VSSE VSSE NCH_HVT W=1.04U L=0.06U M=1 $name=/dlynand2/N01
M238 NET651 MBLN HNET539 VSSE NCH_HVT W=1.04U L=0.06U M=1 $name=/dlynand2/N00
M239 VDDPE NET710 NET651 VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/dlynand2/P10
M24 HNET197 AY4 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N01
M240 VDDPE MBLN NET651 VDDCE PCH_HVT W=0.72U L=0.06U M=1 $name=/dlynand2/P00
M241 HNET543 LONGEMA VSSE VSSE NCH_HVT W=1.07U L=0.06U M=1 $name=/dlynand0/N01
M242 NET655 DELAYEDGTP HNET543 VSSE NCH_HVT W=1.07U L=0.06U M=1 $name=/dlynand0/N00
M243 VDDPE LONGEMA NET655 VDDCE PCH_HVT W=0.73U L=0.06U M=1 $name=/dlynand0/P10
M244 VDDPE DELAYEDGTP NET655 VDDCE PCH_HVT W=0.73U L=0.06U M=1 $name=/dlynand0/P00
M245 HNET547 MBLN VSSE VSSE NCH_HVT W=1.86U L=0.06U M=1 $name=/dlydrv0/N01
M246 NET740 EMAPRE HNET547 VSSE NCH_HVT W=1.86U L=0.06U M=1 $name=/dlydrv0/N00
M247 VDDPE MBLN NET740 VDDCE PCH_HVT W=1.26U L=0.06U M=1 $name=/dlydrv0/P10
M248 VDDPE EMAPRE NET740 VDDCE PCH_HVT W=1.26U L=0.06U M=1 $name=/dlydrv0/P00
M249 HNET551 EMA0N VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I137/N01
M25 NET394 AY3 HNET197 VSSE NCH W=1.25U L=0.06U M=1 $name=/tioypnd/N00
M250 EMA10B NET720 HNET551 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I137/N00
M251 VDDPE EMA0N EMA10B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I137/P10
M252 VDDPE NET720 EMA10B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I137/P00
M253 HNET555 NET722 VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I136/N01
M254 EMA11B NET720 HNET555 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I136/N00
M255 VDDPE NET722 EMA11B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I136/P10
M256 VDDPE NET720 EMA11B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I136/P00
M257 HNET559 NET722 VSSE VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I12/N01
M258 EMA01B EMA1N HNET559 VSSE NCH_HVT W=0.43U L=0.06U M=1 $name=/I12/N00
M259 VDDPE NET722 EMA01B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I12/P10
M26 VDDPE AY4 NET394 VDDCE PCH W=2.5U L=0.06U M=1 $name=/tioypnd/P10
M260 VDDPE EMA1N EMA01B VDDCE PCH_HVT W=0.29U L=0.06U M=1 $name=/I12/P00
M261 HNET566 MBLN VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I30/NI00
M262 NET731 MBLSEL HNET566 VSSE NCH W=0.3U L=0.06U M=1 $name=/I30/NE00
M263 HNET561 MBLSELN NET731 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I30/PE00
M264 VDDCE MBLN HNET561 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I30/PI00
M265 HNET572 STOVREMA VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I28/NI00
M266 NET731 MBLSELN HNET572 VSSE NCH W=0.3U L=0.06U M=1 $name=/I28/NE00
M267 HNET567 MBLSEL NET731 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I28/PE00
M268 VDDCE STOVREMA HNET567 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I28/PI00
M269 HNET578 NET736 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I26/NI00
M27 VDDPE AY3 NET394 VDDCE PCH W=2.5U L=0.06U M=1 $name=/tioypnd/P00
M270 STOVREMA STOVI HNET578 VSSE NCH W=0.3U L=0.06U M=1 $name=/I26/NE00
M271 HNET573 STOVB STOVREMA VDDCE PCH W=0.6U L=0.06U M=1 $name=/I26/PE00
M272 VDDCE NET736 HNET573 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I26/PI00
M273 HNET584 NET740 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I25/NI00
M274 STOVREMA STOVB HNET584 VSSE NCH W=0.3U L=0.06U M=1 $name=/I25/NE00
M275 HNET579 STOVI STOVREMA VDDCE PCH W=0.6U L=0.06U M=1 $name=/I25/PE00
M276 VDDCE NET740 HNET579 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I25/PI00
M277 HNET590 NET745 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretntri/NI00
M278 NET410 NET745 HNET590 VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretntri/NE00
M279 HNET585 NET745 NET410 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tiretntri/PE00
M28 HNET204 NET398 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I37/N11
M280 VDDCE NET745 HNET585 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tiretntri/PI00
M281 HNET596 IRET VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I10/NI00
M282 NET745 IRET HNET596 VSSE NCH W=0.15U L=0.06U M=1 $name=/I10/NE00
M283 HNET591 IRET NET745 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I10/PE00
M284 VDDCE IRET HNET591 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I10/PI00
M285 GTPDSF NET798 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I24/N00
M286 VDDPE NET798 GTPDSF VDDCE PCH W=0.3U L=0.06U M=1 $name=/I24/P00
M287 NET389 MGDLE VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/taptdrvb/N00
M288 VDDPE MGDLE NET389 VDDCE PCH W=0.75U L=0.06U M=1 $name=/taptdrvb/P00
M289 MGTPS NET756 VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I7/N00
M29 NET833 NET396 HNET204 VSSE NCH W=1.25U L=0.06U M=1 $name=/I37/N10
M290 VDDPE NET756 MGTPS VDDCE PCH W=6U L=0.06U M=1 $name=/I7/P00
M291 NET756 GTP VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/I8/N00
M292 VDDPE GTP NET756 VDDCE PCH W=2U L=0.06U M=1 $name=/I8/P00
M293 AGTPN AGTP VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I168/N00
M294 VDDPE AGTP AGTPN VDDCE PCH W=3.52U L=0.06U M=1 $name=/I168/P00
M295 NET760 NET731 VSSE VSSE NCH W=0.35U L=0.06U M=1 $name=/I31/N00
M296 VDDPE NET731 NET760 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I31/P00
M297 WBTDD NET764 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/twbtdrv/N00
M298 VDDPE NET764 WBTDD VDDCE PCH W=1.5U L=0.06U M=1 $name=/twbtdrv/P00
M299 NET764 PWBT VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/twbtb/N00
M3 DELAYEDMBL NET828 HNET179 VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N20
M30 HNET202 NET398 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I37/N01
M300 VDDPE PWBT NET764 VDDCE PCH W=0.5U L=0.06U M=1 $name=/twbtb/P00
M301 IRET RETDD VSSE VSSE NCH W=3U L=0.06U M=1 $name=/tretdrv/N00
M302 VDDCE RETDD IRET VDDCE PCH W=6U L=0.06U M=1 $name=/tretdrv/P00
M303 RETDD NET409 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/tretdd/N00
M304 VDDCE NET409 RETDD VDDCE PCH W=1U L=0.06U M=1 $name=/tretdd/P00
M305 RDT NET772 VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/trdtdrv/N00
M306 VDDPE NET772 RDT VDDCE PCH W=3U L=0.06U M=1 $name=/trdtdrv/P00
M307 NET772 PRDT VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/trdtb/N00
M308 VDDPE PRDT NET772 VDDCE PCH W=1U L=0.06U M=1 $name=/trdtb/P00
M309 MBLN MBL VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/tmblndrv/N00
M31 NET833 NET396 HNET202 VSSE NCH W=1.25U L=0.06U M=1 $name=/I37/N00
M310 VDDPE MBL MBLN VDDCE PCH W=1U L=0.06U M=1 $name=/tmblndrv/P00
M311 DELAYEDGTP NET405 VSSE VSSE NCH W=1.11U L=0.06U M=1 $name=/tlond/N00
M312 VDDPE NET405 DELAYEDGTP VDDCE PCH W=1.48U L=0.06U M=1 $name=/tlond/P00
M313 NET819 WELOUT VSSE VSSE NCH W=0.71U L=0.06U M=1 $name=/tlgweninv2/N00
M314 VDDPE WELOUT NET819 VDDCE PCH W=0.98U L=0.06U M=1 $name=/tlgweninv2/P00
M315 RGWE RGWEB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tlgweninv1/N00
M316 VDDPE RGWEB RGWE VDDCE PCH W=0.2U L=0.06U M=1 $name=/tlgweninv1/P00
M317 IRETN NET783 VSSE VSSE NCH W=0.79U L=0.06U M=1 $name=/tiretndrv/N00
M318 VDDCE NET783 IRETN VDDCE PCH W=1.08U L=0.06U M=1 $name=/tiretndrv/P00
M319 NET783 NET785 VSSE VSSE NCH W=0.27U L=0.06U M=1 $name=/tiretnd/N00
M32 VDDPE NET398 NET833 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I37/P10
M320 VDDCE NET785 NET783 VDDCE PCH W=0.36U L=0.06U M=1 $name=/tiretnd/P00
M321 YP1_3 NET394 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tioypdrv0/N00
M322 VDDPE NET394 YP1_3 VDDCE PCH W=10U L=0.06U M=1 $name=/tioypdrv0/P00
M323 NET396 AY3 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/tinvaydd/N00
M324 VDDPE AY3 NET396 VDDCE PCH W=1.6U L=0.06U M=1 $name=/tinvaydd/P00
M325 IOGTPR IOGTPN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tgtprstdrv/N00
M326 VDDPE IOGTPN IOGTPR VDDCE PCH W=10U L=0.06U M=1 $name=/tgtprstdrv/P00
M327 GTPNDDW NET796 VSSE VSSE NCH W=0.37U L=0.06U M=1 $name=/tgtpnddwdrv/N00
M328 VDDPE NET796 GTPNDDW VDDCE PCH W=0.5U L=0.06U M=1 $name=/tgtpnddwdrv/P00
M329 RGWEN RGWE VSSE VSSE NCH W=0.16U L=0.06U M=1 $name=/tgtpdinv/N00
M33 VDDPE NET396 NET833 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I37/P00
M330 VDDPE RGWE RGWEN VDDCE PCH W=0.22U L=0.06U M=1 $name=/tgtpdinv/P00
M331 NET796 GTPB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tgtpddwdrv/N00
M332 VDDPE GTPB NET796 VDDCE PCH W=0.17U L=0.06U M=1 $name=/tgtpddwdrv/P00
M333 NET798 NET682 VSSE VSSE NCH W=1.75U L=0.06U M=1 $name=/tgtpddrv2/N00
M334 VDDPE NET682 NET798 VDDCE PCH W=2.5U L=0.06U M=1 $name=/tgtpddrv2/P00
M335 GTPDS NET798 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/tgtpddrv1/N00
M336 VDDPE NET798 GTPDS VDDCE PCH W=7U L=0.06U M=1 $name=/tgtpddrv1/P00
M337 A NET807 VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tgset3/N00
M338 VDDPE NET807 A VDDCE PCH W=3U L=0.06U M=1 $name=/tgset3/P00
M339 NET804 CLKCEGTPIN VSSE VSSE NCH W=0.77U L=0.06U M=1 $name=/tgset2/N00
M34 HNET209 NET398 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I36/N11
M340 VDDPE CLKCEGTPIN NET804 VDDCE PCH W=1.05U L=0.06U M=1 $name=/tgset2/P00
M341 CLKCEGTPIN NET807 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tgset/N00
M342 VDDPE NET807 CLKCEGTPIN VDDCE PCH W=0.15U L=0.06U M=1 $name=/tgset/P00
M343 FIOGTPR DELAYEDMBL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tfiogtpdrv/N00
M344 VDDPE DELAYEDMBL FIOGTPR VDDCE PCH W=10U L=0.06U M=1 $name=/tfiogtpdrv/P00
M345 CKI NET691 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tckidrv/N00
M346 VDDPE NET691 CKI VDDCE PCH W=0.15U L=0.06U M=1 $name=/tckidrv/P00
M347 IWE WEI VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/tcewedrvb/N00
M348 VDDPE WEI IWE VDDCE PCH W=3U L=0.06U M=1 $name=/tcewedrvb/P00
M349 CE_WE IWE VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tcewedrv/N00
M35 NET400 AY3 HNET209 VSSE NCH W=1.25U L=0.06U M=1 $name=/I36/N10
M350 VDDPE IWE CE_WE VDDCE PCH W=10U L=0.06U M=1 $name=/tcewedrv/P00
M351 NET398 AY4 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/tay1/N00
M352 VDDPE AY4 NET398 VDDCE PCH W=1.6U L=0.06U M=1 $name=/tay1/P00
M353 LGWE NET819 VSSE VSSE NCH W=0.86U L=0.06U M=1 $name=/gwepdrv/N00
M354 VDDPE NET819 LGWE VDDCE PCH W=1.17U L=0.06U M=1 $name=/gwepdrv/P00
M355 LGWEN LGWE VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gwedrv/N00
M356 VDDPE LGWE LGWEN VDDCE PCH W=4U L=0.06U M=1 $name=/gwedrv/P00
M357 MGDLS MSI VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gmgdldrv1/N00
M358 VDDPE MSI MGDLS VDDCE PCH W=5U L=0.06U M=1 $name=/gmgdldrv1/P00
M359 NET827 PIOGTPN VSSE VSSE NCH W=0.75U L=0.06U M=1 $name=/giogtpinv2/N00
M36 HNET207 NET398 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I36/N01
M360 VDDPE PIOGTPN NET827 VDDCE PCH W=1.5U L=0.06U M=1 $name=/giogtpinv2/P00
M361 IOGTPN NET827 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/giogtpinv1/N00
M362 VDDPE NET827 IOGTPN VDDCE PCH W=5U L=0.06U M=1 $name=/giogtpinv1/P00
M363 NET828 NET760 VSSE VSSE NCH W=1.84U L=0.06U M=1 $name=/ginv1/N00
M364 VDDPE NET760 NET828 VDDCE PCH W=2.5U L=0.06U M=1 $name=/ginv1/P00
M365 IOGTPL IOGTPN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I53/N00
M366 VDDPE IOGTPN IOGTPL VDDCE PCH W=10U L=0.06U M=1 $name=/I53/P00
M367 YP1_0 NET833 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I41/N00
M368 VDDPE NET833 YP1_0 VDDCE PCH W=10U L=0.06U M=1 $name=/I41/P00
M369 YP1_2 NET403 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I40/N00
M37 NET400 AY3 HNET207 VSSE NCH W=1.25U L=0.06U M=1 $name=/I36/N00
M370 VDDPE NET403 YP1_2 VDDCE PCH W=10U L=0.06U M=1 $name=/I40/P00
M371 YP1_1 NET400 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I39/N00
M372 VDDPE NET400 YP1_1 VDDCE PCH W=10U L=0.06U M=1 $name=/I39/P00
M373 TIELOW TIEHIGH VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I140/N00
M374 VDDPE TIEHIGH TIELOW VDDCE PCH W=0.9U L=0.06U M=1 $name=/I140/P00
M375 CLKB CLK VSSE VSSE NCH W=8.76U L=0.06U M=1 $name=/I127/N00
M376 VDDPE CLK CLKB VDDCE PCH W=13.2U L=0.06U M=1 $name=/I127/P00
M377 FIOGTPL DELAYEDMBL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I110/N00
M378 VDDPE DELAYEDMBL FIOGTPL VDDCE PCH W=10U L=0.06U M=1 $name=/I110/P00
M379 NET409 RETN VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I0/N00
M38 VDDPE NET398 NET400 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I36/P10
M380 VDDCE RETN NET409 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I0/P00
M39 VDDPE AY3 NET400 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I36/P00
M4 HNET183 GTP VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N11
M40 HNET214 AY4 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I35/N11
M41 NET403 NET396 HNET214 VSSE NCH W=1.25U L=0.06U M=1 $name=/I35/N10
M42 HNET212 AY4 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/I35/N01
M43 NET403 NET396 HNET212 VSSE NCH W=1.25U L=0.06U M=1 $name=/I35/N00
M44 VDDPE AY4 NET403 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I35/P10
M45 VDDPE NET396 NET403 VDDCE PCH W=2.5U L=0.06U M=1 $name=/I35/P00
M46 NET405 MWLLATE VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I33/N10
M47 NET405 GTP VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I33/N00
M48 VDDPE MWLLATE HNET216 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I33/P01
M49 HNET216 GTP NET405 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I33/P00
M5 DELAYEDMBL NET828 HNET183 VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N10
M50 NET785 NET409 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretnnor/N10
M51 NET785 NET410 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tiretnnor/N00
M52 VDDCE NET409 HNET220 VDDCE PCH W=0.25U L=0.06U M=1 $name=/tiretnnor/P01
M53 HNET220 NET410 NET785 VDDCE PCH W=0.25U L=0.06U M=1 $name=/tiretnnor/P00
M54 AB IRET VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tabdrv/N10
M55 AB CLKCE VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tabdrv/N00
M56 VDDPE IRET HNET224 VDDCE PCH W=1.2U L=0.06U M=1 $name=/tabdrv/P01
M57 HNET224 CLKCE AB VDDCE PCH W=1.2U L=0.06U M=1 $name=/tabdrv/P00
M58 PIOGTPN GTPDED VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N20
M59 PIOGTPN GTPDS VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N10
M6 HNET178 GTP VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N01
M60 PIOGTPN GTP VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnor/N00
M61 VDDPE GTPDED HNET233 VDDCE PCH W=1U L=0.06U M=1 $name=/giogtpnor/P02
M62 HNET233 GTPDS HNET230 VDDCE PCH W=1U L=0.06U M=1 $name=/giogtpnor/P01
M63 HNET230 GTP PIOGTPN VDDCE PCH W=1U L=0.06U M=1 $name=/giogtpnor/P00
M64 HNET238 EMA0N VSSE VSSE NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N02
M65 HNET239 EMA1N HNET238 VSSE NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N01
M66 EMA000N EMA2N HNET239 VSSE NCH_HVT W=0.62U L=0.06U M=1 $name=/emanand0/N00
M67 VDDPE EMA0N EMA000N VDDCE PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P20
M68 VDDPE EMA1N EMA000N VDDCE PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P10
M69 VDDPE EMA2N EMA000N VDDCE PCH_HVT W=0.43U L=0.06U M=1 $name=/emanand0/P00
M7 DELAYEDMBL NET828 HNET178 VSSE NCH W=2U L=0.06U M=1 $name=/gfiogtpnd/N00
M70 MBLSEL EMA000N VSSE VSSE NCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel1/N10
M71 MBLSEL STOVI VSSE VSSE NCH_HVT W=0.4U L=0.06U M=1 $name=/mblsel1/N00
M72 VDDPE EMA000N HNET240 VDDCE PCH_HVT W=0.8U L=0.06U M=1 $name=/mblsel1/P01
M73 HNET240 STOVI MBLSEL VDDCE PCH_HVT W=0.8U L=0.06U M=1 $name=/mblsel1/P00
M74 NET653 EMA2N VSSE VSSE NCH_HVT W=0.52U L=0.06U M=1 $name=/dlynord1/N10
M75 NET653 NET427 VSSE VSSE NCH_HVT W=0.52U L=0.06U M=1 $name=/dlynord1/N00
M76 VDDPE EMA2N HNET244 VDDCE PCH_HVT W=1.43U L=0.06U M=1 $name=/dlynord1/P01
M77 HNET244 NET427 NET653 VDDCE PCH_HVT W=1.43U L=0.06U M=1 $name=/dlynord1/P00
M78 VDDPE CKI SETGTP VDDCE PCH_HVT W=0.75U L=0.06U M=1 $name=/tgtpen/P00
M79 VDDPE GTP VDDPE VDDCE PCH_HVT W=0.3U L=0.12U M=1 $name=/tdlyp3b/P00
M8 VDDPE GTP DELAYEDMBL VDDCE PCH W=8U L=0.06U M=1 $name=/gfiogtpnd/P10
M80 NET427 EMA00B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/dlypassp/P00
M81 NET442 TIELOW NET604 VDDCE PCH_HVT W=0.45U L=0.12U M=1 $name=/P7/P00
M82 VDDPE TIELOW NET442 VDDCE PCH_HVT W=0.45U L=0.12U M=1 $name=/P6/P00
M83 NET537 EMA11B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/P29/P00
M84 NET707 EMA10B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/P28/P00
M85 NET710 EMA01B EMAPRE VDDCE PCH_HVT W=0.89U L=0.06U M=1 $name=/P25/P00
M86 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P13/P00
M87 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P12/P00
M88 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P11/P00
M89 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P10/P00
M9 VDDPE NET828 DELAYEDMBL VDDCE PCH W=8U L=0.06U M=1 $name=/gfiogtpnd/P00
M90 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/P9/P00
M91 WELOUT AGTP WEI VDDCE PCH W=0.36U L=0.06U M=1 $name=/tpgwep4/P00
M92 RGWEB AGTPN NET819 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpgwep3/P00
M93 NET626 AGTP RGWEB VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpgwep2/P00
M94 NET565 AGTPN WELOUT VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpgwep1/P00
M95 VDDPE GTPDEI VDDPE VDDCE PCH W=0.45U L=0.12U M=1 $name=/tpgtpdeskew2/P00
M96 VDDPE DELAYEDGTP MBL VDDCE PCH W=3U L=0.06U M=1 $name=/tkpmbl/P00
M97 VDDPE A SETGTP VDDCE PCH W=9.3U L=0.06U M=1 $name=/tgtpset/P00
M98 VDDPE SETGTP GTP VDDCE PCH W=3U L=0.06U M=1 $name=/tgtpdrvp/P00
M99 VDDPE GTPB GTP VDDCE PCH W=6.3U L=0.06U M=1 $name=/tgpdrvp2/P00
.ENDS lut_sram_1024x16CTRL_1B
****
.SUBCKT lut_sram_1024x16AL_1B A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N
+  A11N A12N A13N AGTP AGTPN AI5 AI6 AI7 AI8 AI9 AI10 AI11 AI12 AI13 AX0N AX1N
+  AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N AY3 AY4 BS0N BS1N BSN_MSB
+  CE_WE_TRACK FIOGTP_TRACK IOGTP_TRACK LAT11 LAT12 LAT13 MATCH0 MATCH1 MATCH2
+  MATCH3 RETN_TRACK RET_TRACK RREN RXP0 RXP1 RXP2 RXP3 TIEHIGH TIELOW
+  YP0_TRACK YP1_TRACK YP2_TRACK YP3_TRACK VSSE VDDPE VDDCE
** lut_sram_1024x16AL_1B: 192 flat devices **
M0 HNET126 NET339 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I6/NI00
M1 NET338 AGTP HNET126 VSSE NCH W=0.2U L=0.06U M=1 $name=/I6/NE00
M10 HNET134 AGTPN NET525 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I7/PE00
M100 RXP1 NET510 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I5/N00
M101 VDDPE NET510 RXP1 VDDCE PCH W=2U L=0.06U M=1 $name=/I5/P00
M102 RXP0 NET514 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/trra/N00
M103 VDDPE NET514 RXP0 VDDCE PCH W=2U L=0.06U M=1 $name=/trra/P00
M104 RXP3 NET508 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I1/N00
M105 VDDPE NET508 RXP3 VDDCE PCH W=2U L=0.06U M=1 $name=/I1/P00
M106 RXP2 NET512 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I2/N00
M107 VDDPE NET512 RXP2 VDDCE PCH W=2U L=0.06U M=1 $name=/I2/P00
M108 AI12 NET525 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I96/N00
M109 VDDPE NET525 AI12 VDDCE PCH W=4U L=0.06U M=1 $name=/I96/P00
M11 VDDPE NET536 HNET134 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I7/PI00
M110 AY1N NET355 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I30/N00
M111 VDDPE NET355 AY1N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I30/P00
M112 RREN NET386 VSSE VSSE NCH W=4.5U L=0.06U M=1 $name=/trrendrv/N00
M113 VDDPE NET386 RREN VDDCE PCH W=9U L=0.06U M=1 $name=/trrendrv/P00
M114 AI13 NET338 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/trre/N00
M115 VDDPE NET338 AI13 VDDCE PCH W=4U L=0.06U M=1 $name=/trre/P00
M116 NET339 NET338 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/taddrdrvb/N00
M117 VDDPE NET338 NET339 VDDCE PCH W=2U L=0.06U M=1 $name=/taddrdrvb/P00
M118 LAT13 NET339 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/taddrdrv/N00
M119 VDDPE NET339 LAT13 VDDCE PCH W=7.04U L=0.06U M=1 $name=/taddrdrv/P00
M12 HNET147 NET351 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I11/NI00
M120 NET536 NET525 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gaidriveb/N00
M121 VDDPE NET525 NET536 VDDCE PCH W=2U L=0.06U M=1 $name=/gaidriveb/P00
M122 NET538 BSN_MSB VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/grrinv3/N00
M123 VDDPE BSN_MSB NET538 VDDCE PCH W=2U L=0.06U M=1 $name=/grrinv3/P00
M124 NET540 BSN_MSB VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/grrinv2/N00
M125 VDDPE BSN_MSB NET540 VDDCE PCH W=2U L=0.06U M=1 $name=/grrinv2/P00
M126 NET542 MATCH1 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/grrinv1/N00
M127 VDDPE MATCH1 NET542 VDDCE PCH W=0.2U L=0.06U M=1 $name=/grrinv1/P00
M128 LAT12 NET536 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/gaidrive/N00
M129 VDDPE NET536 LAT12 VDDCE PCH W=7.04U L=0.06U M=1 $name=/gaidrive/P00
M13 NET589 AGTP HNET147 VSSE NCH W=0.2U L=0.06U M=1 $name=/I11/NE00
M130 LAT11 NET351 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I9/N00
M131 VDDPE NET351 LAT11 VDDCE PCH W=7.04U L=0.06U M=1 $name=/I9/P00
M132 NET548 MATCH2 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I70/N00
M133 VDDPE MATCH2 NET548 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I70/P00
M134 NET550 MATCH3 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I69/N00
M135 VDDPE MATCH3 NET550 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I69/P00
M136 NET552 MATCH0 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I3/N00
M137 VDDPE MATCH0 NET552 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I3/P00
M138 NET554 NET486 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I63/N00
M139 VDDPE NET486 NET554 VDDCE PCH W=2U L=0.06U M=1 $name=/I63/P00
M14 HNET141 AGTPN NET589 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I11/PE00
M140 AI5 NET557 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I62/N00
M141 VDDPE NET557 AI5 VDDCE PCH W=4U L=0.06U M=1 $name=/I62/P00
M142 AXL0 NET557 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I60/N00
M143 VDDPE NET557 AXL0 VDDCE PCH W=2U L=0.06U M=1 $name=/I60/P00
M144 AI7 NET561 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I56/N00
M145 VDDPE NET561 AI7 VDDCE PCH W=4U L=0.06U M=1 $name=/I56/P00
M146 AI6 NET474 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I59/N00
M147 VDDPE NET474 AI6 VDDCE PCH W=4U L=0.06U M=1 $name=/I59/P00
M148 NET367 NET561 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I54/N00
M149 VDDPE NET561 NET367 VDDCE PCH W=2U L=0.06U M=1 $name=/I54/P00
M15 VDDPE NET351 HNET141 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I11/PI00
M150 AX2N NET367 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I19/N00
M151 VDDPE NET367 AX2N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I19/P00
M152 NET568 NET474 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I57/N00
M153 VDDPE NET474 NET568 VDDCE PCH W=2U L=0.06U M=1 $name=/I57/P00
M154 AX1N NET568 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I18/N00
M155 VDDPE NET568 AX1N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I18/P00
M156 AI8 NET492 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I53/N00
M157 VDDPE NET492 AI8 VDDCE PCH W=4U L=0.06U M=1 $name=/I53/P00
M158 NET574 NET492 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I51/N00
M159 VDDPE NET492 NET574 VDDCE PCH W=2U L=0.06U M=1 $name=/I51/P00
M16 HNET154 NET355 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I22/NI00
M160 NET371 NET579 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I50/N00
M161 VDDPE NET579 NET371 VDDCE PCH W=2U L=0.06U M=1 $name=/I50/P00
M162 AI9 NET579 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I48/N00
M163 VDDPE NET579 AI9 VDDCE PCH W=4U L=0.06U M=1 $name=/I48/P00
M164 NET355 NET354 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I65/N00
M165 VDDPE NET354 NET355 VDDCE PCH W=2U L=0.06U M=1 $name=/I65/P00
M166 AI10 NET498 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I43/N00
M167 VDDPE NET498 AI10 VDDCE PCH W=4U L=0.06U M=1 $name=/I43/P00
M168 NET584 NET498 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I42/N00
M169 VDDPE NET498 NET584 VDDCE PCH W=2U L=0.06U M=1 $name=/I42/P00
M17 NET354 AGTP HNET154 VSSE NCH W=0.2U L=0.06U M=1 $name=/I22/NE00
M170 NET351 NET589 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I40/N00
M171 VDDPE NET589 NET351 VDDCE PCH W=2U L=0.06U M=1 $name=/I40/P00
M172 AI11 NET589 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I39/N00
M173 VDDPE NET589 AI11 VDDCE PCH W=4U L=0.06U M=1 $name=/I39/P00
M174 AYL0 AY0NLOUT VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I46/N00
M175 VDDPE AY0NLOUT AYL0 VDDCE PCH W=2U L=0.06U M=1 $name=/I46/P00
M176 AY0N AYL0 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I31/N00
M177 VDDPE AYL0 AY0N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I31/P00
M178 AY3 A3N VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I27/N00
M179 VDDPE A3N AY3 VDDCE PCH W=2.4U L=0.06U M=1 $name=/I27/P00
M18 HNET148 AGTPN NET354 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I22/PE00
M180 AY4 A4N VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I26/N00
M181 VDDPE A4N AY4 VDDCE PCH W=2.4U L=0.06U M=1 $name=/I26/P00
M182 AY2N NET554 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I25/N00
M183 VDDPE NET554 AY2N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I25/P00
M184 AX0N AXL0 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I24/N00
M185 VDDPE AXL0 AX0N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I24/P00
M186 AX3N NET574 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I17/N00
M187 VDDPE NET574 AX3N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I17/P00
M188 AX4N NET371 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I16/N00
M189 VDDPE NET371 AX4N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I16/P00
M19 VDDPE NET355 HNET148 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I22/PI00
M190 AX5N NET584 VSSE VSSE NCH W=3.52U L=0.06U M=1 $name=/I10/N00
M191 VDDPE NET584 AX5N VDDCE PCH W=7.04U L=0.06U M=1 $name=/I10/P00
M2 HNET120 AGTPN NET338 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I6/PE00
M20 HNET161 NET554 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I23/NI00
M21 NET486 AGTP HNET161 VSSE NCH W=0.2U L=0.06U M=1 $name=/I23/NE00
M22 HNET155 AGTPN NET486 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I23/PE00
M23 VDDPE NET554 HNET155 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I23/PI00
M24 HNET168 AXL0 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I20/NI00
M25 NET557 AGTP HNET168 VSSE NCH W=0.2U L=0.06U M=1 $name=/I20/NE00
M26 HNET162 AGTPN NET557 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I20/PE00
M27 VDDPE AXL0 HNET162 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I20/PI00
M28 HNET175 NET367 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I14/NI00
M29 NET561 AGTP HNET175 VSSE NCH W=0.2U L=0.06U M=1 $name=/I14/NE00
M3 VDDPE NET339 HNET120 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I6/PI00
M30 HNET169 AGTPN NET561 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I14/PE00
M31 VDDPE NET367 HNET169 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I14/PI00
M32 HNET182 NET371 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I12/NI00
M33 NET579 AGTP HNET182 VSSE NCH W=0.2U L=0.06U M=1 $name=/I12/NE00
M34 HNET176 AGTPN NET579 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I12/PE00
M35 VDDPE NET371 HNET176 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I12/PI00
M36 HNET189 NET574 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I15/NI00
M37 NET492 AGTP HNET189 VSSE NCH W=0.2U L=0.06U M=1 $name=/I15/NE00
M38 HNET183 AGTPN NET492 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I15/PE00
M39 VDDPE NET574 HNET183 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I15/PI00
M4 HNET133 AYL0 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I28/NI00
M40 HNET196 NET568 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I21/NI00
M41 NET474 AGTP HNET196 VSSE NCH W=0.2U L=0.06U M=1 $name=/I21/NE00
M42 HNET190 AGTPN NET474 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I21/PE00
M43 VDDPE NET568 HNET190 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I21/PI00
M44 HNET203 NET584 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I13/NI00
M45 NET498 AGTP HNET203 VSSE NCH W=0.2U L=0.06U M=1 $name=/I13/NE00
M46 HNET197 AGTPN NET498 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I13/PE00
M47 VDDPE NET584 HNET197 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I13/PI00
M48 HNET206 NET470 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/trrnand/N01
M49 NET386 NET479 HNET206 VSSE NCH W=3.5U L=0.06U M=1 $name=/trrnand/N00
M5 AY0NLOUT AGTP HNET133 VSSE NCH W=0.2U L=0.06U M=1 $name=/I28/NE00
M50 VDDPE NET470 NET386 VDDCE PCH W=2.92U L=0.06U M=1 $name=/trrnand/P10
M51 VDDPE NET479 NET386 VDDCE PCH W=2.92U L=0.06U M=1 $name=/trrnand/P00
M52 NET474 AGTP A6N VDDCE PCH W=2U L=0.06U M=1 $name=/P36/P00
M53 NET540 NET542 NET470 VDDCE PCH W=1.2U L=0.06U M=1 $name=/trrpgp/P00
M54 NET540 NET552 NET470 VDDCE PCH W=1.2U L=0.06U M=1 $name=/P8/P00
M55 NET399 MATCH0 NET470 VDDCE PCH W=2U L=0.06U M=1 $name=/trrpu/P00
M56 VDDPE TIELOW TIEHIGH VDDCE PCH W=4.5U L=0.06U M=1 $name=/tarefp/P00
M57 NET338 AGTP A13N VDDCE PCH W=2U L=0.06U M=1 $name=/tapgp/P00
M58 NET557 AGTP A5N VDDCE PCH W=2U L=0.06U M=1 $name=/taiop2/P00
M59 AY0NLOUT AGTP A0N VDDCE PCH W=2U L=0.06U M=1 $name=/taiop/P00
M6 HNET127 AGTPN AY0NLOUT VDDCE PCH W=0.3U L=0.06U M=1 $name=/I28/PE00
M60 VDDPE MATCH1 NET399 VDDCE PCH W=2U L=0.06U M=1 $name=/P5/P00
M61 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P79/P00
M62 VDDPE MATCH3 NET423 VDDCE PCH W=2U L=0.06U M=1 $name=/P4/P00
M63 NET423 MATCH2 NET479 VDDCE PCH W=2U L=0.06U M=1 $name=/P3/P00
M64 NET538 NET550 NET479 VDDCE PCH W=1.2U L=0.06U M=1 $name=/P2/P00
M65 NET538 NET548 NET479 VDDCE PCH W=1.2U L=0.06U M=1 $name=/P1/P00
M66 NET354 AGTP A1N VDDCE PCH W=2U L=0.06U M=1 $name=/P42/P00
M67 NET486 AGTP A2N VDDCE PCH W=2U L=0.06U M=1 $name=/P40/P00
M68 NET561 AGTP A7N VDDCE PCH W=2U L=0.06U M=1 $name=/P34/P00
M69 NET492 AGTP A8N VDDCE PCH W=2U L=0.06U M=1 $name=/P32/P00
M7 VDDPE AYL0 HNET127 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I28/PI00
M70 NET579 AGTP A9N VDDCE PCH W=2U L=0.06U M=1 $name=/P30/P00
M71 NET498 AGTP A10N VDDCE PCH W=2U L=0.06U M=1 $name=/P27/P00
M72 NET589 AGTP A11N VDDCE PCH W=2U L=0.06U M=1 $name=/P26/P00
M73 NET525 AGTP A12N VDDCE PCH W=2U L=0.06U M=1 $name=/P19/P00
M74 TIELOW TIEHIGH VSSE VSSE NCH W=3.3U L=0.06U M=1 $name=/tarefn/N00
M75 NET338 AGTPN A13N VSSE NCH W=2U L=0.06U M=1 $name=/tapgn/N00
M76 NET557 AGTPN A5N VSSE NCH W=2U L=0.06U M=1 $name=/taion2/N00
M77 AY0NLOUT AGTPN A0N VSSE NCH W=2U L=0.06U M=1 $name=/taion/N00
M78 NET540 MATCH1 NET470 VSSE NCH W=1.2U L=0.06U M=1 $name=/trrpgn/N00
M79 NET540 MATCH0 NET470 VSSE NCH W=1.2U L=0.06U M=1 $name=/N4/N00
M8 HNET140 NET536 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I7/NI00
M80 NET474 AGTPN A6N VSSE NCH W=2U L=0.06U M=1 $name=/N37/N00
M81 NET538 MATCH3 NET479 VSSE NCH W=1.2U L=0.06U M=1 $name=/N2/N00
M82 NET538 MATCH2 NET479 VSSE NCH W=1.2U L=0.06U M=1 $name=/N1/N00
M83 NET354 AGTPN A1N VSSE NCH W=2U L=0.06U M=1 $name=/N43/N00
M84 NET486 AGTPN A2N VSSE NCH W=2U L=0.06U M=1 $name=/N41/N00
M85 NET561 AGTPN A7N VSSE NCH W=2U L=0.06U M=1 $name=/N35/N00
M86 NET492 AGTPN A8N VSSE NCH W=2U L=0.06U M=1 $name=/N33/N00
M87 NET579 AGTPN A9N VSSE NCH W=2U L=0.06U M=1 $name=/N31/N00
M88 NET498 AGTPN A10N VSSE NCH W=2U L=0.06U M=1 $name=/N28/N00
M89 NET589 AGTPN A11N VSSE NCH W=2U L=0.06U M=1 $name=/N27/N00
M9 NET525 AGTP HNET140 VSSE NCH W=0.2U L=0.06U M=1 $name=/I7/NE00
M90 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N20/N00
M91 NET525 AGTPN A12N VSSE NCH W=2U L=0.06U M=1 $name=/N19/N00
M92 NET508 MATCH3 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/I94/N00
M93 VDDPE MATCH3 NET508 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I94/P00
M94 NET510 MATCH1 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/I4/N00
M95 VDDPE MATCH1 NET510 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I4/P00
M96 NET512 MATCH2 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/I0/N00
M97 VDDPE MATCH2 NET512 VDDCE PCH W=0.7U L=0.06U M=1 $name=/I0/P00
M98 NET514 MATCH0 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/trran/N00
M99 VDDPE MATCH0 NET514 VDDCE PCH W=0.7U L=0.06U M=1 $name=/trran/P00
.ENDS lut_sram_1024x16AL_1B
****
.SUBCKT lut_sram_1024x16BCTRL16M16 A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N
+  A10N A11N A12N A13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0N
+  BS1N CEI CE_WE CLK CREN_TERM_0 CREN_TERM_1 EMA0 EMA1 EMA2 FIOGTP FIOGTPR
+  GDLA_TERM GDLA__TERM GDL_TERM GDL__TERM GTP GTPDET GTPDST IOGTP IOGTPR
+  LGWEN MATCH0 MATCH1 MATCH2 MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE PRDT PWBT
+  RDT RETN RETN_TRACK RET_TRACK RRENDD RXP0 RXP1 RXP2 RXP3 STOV T0L_TERM
+  TIEHIGH_0 TIEHIGH_1 TIELOW_0 TIELOW_1 TL0_TERM WBTDD WEI WE_TERM_0
+  WE_TERM_1 YP0_TRACK YP1_TRACK YP2_TRACK YP3_TRACK YSNA_TERM_0 YSNA_TERM_1
+  VSSE VDDPE VDDCE
** lut_sram_1024x16BCTRL16M16: 575 flat devices **
XINSTAL A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N A13N AGTP AGTPN
+  AI5 AI6 AI7 AI8 AI9 AI10 AI11 AI12 AI13 AX0N AX1N AX2N AX3N AX4N AX5N AX6N
+  AY0N AY1N AY2N AY3 AY4 BS0N BS1N TIEHIGH_1 CE_WE FIOGTP IOGTP BS0N BS1N
+  AX6N MATCH0 MATCH1 MATCH2 MATCH3 RETN_TRACK RET_TRACK RRENDD RXP0 RXP1 RXP2
+  RXP3 TIEHIGH_1 TIELOW_1 YP0_TRACK YP1_TRACK YP2_TRACK YP3_TRACK VSSE VDDPE
+  VDDCE lut_sram_1024x16AL_1B
XINSTCTRL AGTP AGTPN AX6N AY3 AY4 BS0N BS1N CEI CE_WE CLK CREN_TERM_1 EMA0
+  EMA1 EMA2 FIOGTP FIOGTPR GDLA_TERM GDLA__TERM GTP GTPDST GTPDEI GTPDET
+  GTPDST GTPDEI GTPDST IOGTP IOGTPR RET_TRACK RETN_TRACK LGWEN MBL MGDLE
+  MGDLET MGDLE MGDLST MGTPS MWLLATE PRDT PWBT RDT RETN RRENDD STOV TIEHIGH_0
+  TIELOW_0 TL0_TERM WBTDD WEI WE_TERM_1 YP0_TRACK YP1_TRACK YP2_TRACK
+  YP3_TRACK YSNA_TERM_1 VSSE VDDPE VDDCE lut_sram_1024x16CTRL_1B
.ENDS lut_sram_1024x16BCTRL16M16
****
.SUBCKT lut_sram_1024x16IO8_1BRL8 BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5
+  BWEI_6 BWEI_7 CE_WE CREN_0 CREN_1 CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7
+  CREN_8 CREN_9 CREN_10 CREN_11 CREN_12 CREN_13 CREN_14 CREN_15 DNI_0 DNI_1
+  DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 FIOGTP GDLA GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8
+  GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 IOGTP IRET IRETN
+  Q__0 Q__1 Q__2 Q__3 Q__4 Q__5 Q__6 Q__7 TIEHIGH TIELOW YP1_0 YP1_1 YP1_2
+  YP1_3 VSSE VDDPE VDDCE
** lut_sram_1024x16IO8_1BRL8: 2100 flat devices **
XLEFTIO0 BWEI_0 CE_WE TIEHIGH CREN_0 CREN_1 DNI_0 FIOGTP GDLA GDL_0 GDL_1
+  GDL__0 GDL__1 IOGTP IRET IRETN Q__0 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XLEFTIO1 BWEI_1 CE_WE TIEHIGH CREN_2 CREN_3 DNI_1 FIOGTP GDLA GDL_2 GDL_3
+  GDL__2 GDL__3 IOGTP IRET IRETN Q__1 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XLEFTIO2 BWEI_2 CE_WE TIEHIGH CREN_4 CREN_5 DNI_2 FIOGTP GDLA GDL_4 GDL_5
+  GDL__4 GDL__5 IOGTP IRET IRETN Q__2 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XLEFTIO3 BWEI_3 CE_WE TIEHIGH CREN_6 CREN_7 DNI_3 FIOGTP GDLA GDL_6 GDL_7
+  GDL__6 GDL__7 IOGTP IRET IRETN Q__3 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XLEFTIO4 BWEI_4 CE_WE TIEHIGH CREN_8 CREN_9 DNI_4 FIOGTP GDLA GDL_8 GDL_9
+  GDL__8 GDL__9 IOGTP IRET IRETN Q__4 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XLEFTIO5 BWEI_5 CE_WE TIEHIGH CREN_10 CREN_11 DNI_5 FIOGTP GDLA GDL_10 GDL_11
+  GDL__10 GDL__11 IOGTP IRET IRETN Q__5 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XLEFTIO6 BWEI_6 CE_WE TIEHIGH CREN_12 CREN_13 DNI_6 FIOGTP GDLA GDL_12 GDL_13
+  GDL__12 GDL__13 IOGTP IRET IRETN Q__6 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO16HP
XLEFTIOEDGE8 CE_WE TIEHIGH FIOGTP GDLA TIEHIGH IOGTP IRETN IRET TIEHIGH TIELOW
+  GDLA GDLA YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH VSSE VDDPE VDDCE
+  lut_sram_1024x16IO8EDGE_1B
XLEFTIOEXT7 BWEI_7 CE_WE TIEHIGH CREN_14 CREN_15 DNI_7 FIOGTP GDLA GDL_14
+  GDL_15 GDL__14 GDL__15 IOGTP IRET IRETN Q__7 YP1_0 YP1_1 YP1_2 YP1_3 VSSE
+  VDDPE VDDCE lut_sram_1024x16IO16HP
.ENDS lut_sram_1024x16IO8_1BRL8
****
.SUBCKT lut_sram_1024x16BR16IO8_1B A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N
+  A10N A11N A12N A13N AX0N AX1N AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0N
+  BS1N BWEI_0 BWEI_1 BWEI_2 BWEI_3 BWEI_4 BWEI_5 BWEI_6 BWEI_7 BWEI_8 BWEI_9
+  BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15 CEI CLK CREN_0 CREN_1
+  CREN_2 CREN_3 CREN_4 CREN_5 CREN_6 CREN_7 CREN_8 CREN_9 CREN_10 CREN_11
+  CREN_12 CREN_13 CREN_14 CREN_15 CREN_16 CREN_17 CREN_18 CREN_19 CREN_20
+  CREN_21 CREN_22 CREN_23 CREN_24 CREN_25 CREN_26 CREN_27 CREN_28 CREN_29
+  CREN_30 CREN_31 DNI_0 DNI_1 DNI_2 DNI_3 DNI_4 DNI_5 DNI_6 DNI_7 DNI_8 DNI_9
+  DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 EMA0 EMA1 EMA2 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL__0 GDL__1
+  GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11
+  GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20
+  GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29
+  GDL__30 GDL__31 GTP GTPDET GTPDST IRET IRETN LGWEN MATCH0 MATCH1 MATCH2
+  MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE PRDT PWBT Q__0 Q__1 Q__2 Q__3 Q__4
+  Q__5 Q__6 Q__7 Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15 RDT RETN
+  RRENDD RXP0 RXP1 RXP2 RXP3 STOV T0L_TERM TIEHIGH_0 TIEHIGH_1 TIELOW_0
+  TIELOW_1 TIELOW_2 TL0_TERM WBTDD WEI VSSE VDDPE VDDCE
** lut_sram_1024x16BR16IO8_1B: 4775 flat devices **
XBOTCTRL A0N A1N A2N A3N A4N A5N A6N A7N A8N A9N A10N A11N A12N A13N AX0N AX1N
+  AX2N AX3N AX4N AX5N AX6N AY0N AY1N AY2N BS0N BS1N CEI CE_WE CLK TIEHIGH_0
+  TIEHIGH_1 EMA0 EMA1 EMA2 FIOGTP_8 FIOGTP TIELOW_1 TIEHIGH_1 WE_TERM_0
+  TIEHIGH_0 GTP GTPDET GTPDST IOGTP_10 IOGTP LGWEN MATCH0 MATCH1 MATCH2
+  MATCH3 MBL MGDLET MGDLST MGTPS MWLLATE PRDT PWBT RDT RETN IRETN IRET RRENDD
+  RXP0 RXP1 RXP2 RXP3 STOV T0L_TERM TIEHIGH_1 TIEHIGH_0 TIELOW_1 WE_TERM_0
+  TL0_TERM WBTDD WEI WE_TERM_0 TIELOW_1 YP1_0 YP1_1 YP1_2 YP1_3 TIEHIGH_0
+  TIEHIGH_1 VSSE VDDPE VDDCE lut_sram_1024x16BCTRL16M16
XLEFTIOROW BWEI_7 BWEI_6 BWEI_5 BWEI_4 BWEI_3 BWEI_2 BWEI_1 BWEI_0 CE_WE
+  CREN_15 CREN_14 CREN_13 CREN_12 CREN_11 CREN_10 CREN_9 CREN_8 CREN_7 CREN_6
+  CREN_5 CREN_4 CREN_3 CREN_2 CREN_1 CREN_0 DNI_7 DNI_6 DNI_5 DNI_4 DNI_3
+  DNI_2 DNI_1 DNI_0 FIOGTP_8 WE_TERM_0 GDL_15 GDL_14 GDL_13 GDL_12 GDL_11
+  GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0 GDL__15
+  GDL__14 GDL__13 GDL__12 GDL__11 GDL__10 GDL__9 GDL__8 GDL__7 GDL__6 GDL__5
+  GDL__4 GDL__3 GDL__2 GDL__1 GDL__0 IOGTP_10 IRET IRETN Q__7 Q__6 Q__5 Q__4
+  Q__3 Q__2 Q__1 Q__0 TIEHIGH_0 TIELOW_0 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE
+  VDDCE lut_sram_1024x16IO8_1BRL8
XRIGHTIOROW BWEI_8 BWEI_9 BWEI_10 BWEI_11 BWEI_12 BWEI_13 BWEI_14 BWEI_15
+  CE_WE CREN_16 CREN_17 CREN_18 CREN_19 CREN_20 CREN_21 CREN_22 CREN_23
+  CREN_24 CREN_25 CREN_26 CREN_27 CREN_28 CREN_29 CREN_30 CREN_31 DNI_8 DNI_9
+  DNI_10 DNI_11 DNI_12 DNI_13 DNI_14 DNI_15 FIOGTP TIELOW_1 GDL_16 GDL_17
+  GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27
+  GDL_28 GDL_29 GDL_30 GDL_31 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21
+  GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30
+  GDL__31 IOGTP IRET IRETN Q__8 Q__9 Q__10 Q__11 Q__12 Q__13 Q__14 Q__15
+  TIEHIGH_1 TIELOW_2 YP1_0 YP1_1 YP1_2 YP1_3 VSSE VDDPE VDDCE
+  lut_sram_1024x16IO8_1BRR8
.ENDS lut_sram_1024x16BR16IO8_1B
****
.SUBCKT lut_sram_1024x16CD8_1B BL0 BL0_ BL1 BL1_ BL2 BL2_ BL3 BL3_ BL4 BL4_
+  BL5 BL5_ BL6 BL6_ BL7 BL7_ BTP DR DRPREN DR_ DW DW_ GDL GDL_ YP0N YP0_0N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N YP1N YP2N YP3N YP4N YP5N
+  YP6N YP7N VSSE VDDPE VDDCE
** lut_sram_1024x16CD8_1B: 100 flat devices **
M0 BL0 YPPASS0 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/tblpass/P00
M1 BL1_ YPPASS1 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P14/P00
M10 BL4 YPPASS4 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P46/P00
M11 BL5_ YPPASS5 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P52/P00
M12 BL6 YPPASS6 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P55/P00
M13 BL6_ YPPASS6 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P60/P00
M14 BL7 YPPASS7 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P62/P00
M15 BL7_ YPPASS7 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P61/P00
M16 VDDPE NET284 PRE0 VDDCE PCH W=0.88U L=0.06U M=1 $name=/P73/P00
M17 VDDPE NET287 PRE3 VDDCE PCH W=0.88U L=0.06U M=1 $name=/P75/P00
M18 BL2_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P20/P00
M19 BL7_ PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P58/P00
M2 BL0_ YPPASS0 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P53/P00
M20 BL3_ PRE0 BL3 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P28/P00
M21 BL0 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/tpre/P00
M22 BL0_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P0/P00
M23 BL0_ PRE0 BL0 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P1/P00
M24 BL1 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P13/P00
M25 BL1_ PRE0 BL1 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P12/P00
M26 BL3_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P27/P00
M27 BL3 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P29/P00
M28 BL2_ PRE0 BL2 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P19/P00
M29 BL2 PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P18/P00
M3 BL1 YPPASS1 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P10/P00
M30 BL5 PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P35/P00
M31 BL4 PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P41/P00
M32 BL5_ PRE3 BL5 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P39/P00
M33 BL5_ PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P44/P00
M34 BL4_ PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P47/P00
M35 BL6 PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P51/P00
M36 BL6_ PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P49/P00
M37 BL6_ PRE3 BL6 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P50/P00
M38 BL7_ PRE3 BL7 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P59/P00
M39 BL7 PRE3 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P63/P00
M4 BL2_ YPPASS2 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P17/P00
M40 BL1_ PRE0 VDDPE VDDCE PCH W=0.66U L=0.06U M=1 $name=/P11/P00
M41 BL4_ PRE3 BL4 VDDCE PCH W=0.66U L=0.06U M=1 $name=/P48/P00
M42 VDDPE DRPREN DR_ VDDCE PCH W=0.34U L=0.06U M=1 $name=/P9/P00
M43 VDDPE DRPREN DR VDDCE PCH W=0.34U L=0.06U M=1 $name=/P8/P00
M44 VDDPE DW_ DR VDDCE PCH W=0.34U L=0.06U M=1 $name=/P7/P00
M45 VDDPE DW DR_ VDDCE PCH W=0.34U L=0.06U M=1 $name=/P5/P00
M46 BL5_ YNPASS5 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N10/N00
M47 BL0 YNPASS0 DW VSSE NCH W=1U L=0.06U M=1 $name=/P3/N00
M48 BL1 YNPASS1 DW VSSE NCH W=1U L=0.06U M=1 $name=/N2/N00
M49 BL0_ YNPASS0 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/P4/N00
M5 BL3 YPPASS3 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P26/P00
M50 BL3_ YNPASS3 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N9/N00
M51 BL2 YNPASS2 DW VSSE NCH W=1U L=0.06U M=1 $name=/N5/N00
M52 BL2_ YNPASS2 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N4/N00
M53 BL3 YNPASS3 DW VSSE NCH W=1U L=0.06U M=1 $name=/N8/N00
M54 BL5 YNPASS5 DW VSSE NCH W=1U L=0.06U M=1 $name=/N12/N00
M55 BL4 YNPASS4 DW VSSE NCH W=1U L=0.06U M=1 $name=/N11/N00
M56 BL6_ YNPASS6 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N15/N00
M57 BL7_ YNPASS7 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N18/N00
M58 BL4_ YNPASS4 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N17/N00
M59 BL6 YNPASS6 DW VSSE NCH W=1U L=0.06U M=1 $name=/N21/N00
M6 BL3_ YPPASS3 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P30/P00
M60 BL7 YNPASS7 DW VSSE NCH W=1U L=0.06U M=1 $name=/N19/N00
M61 BL1_ YNPASS1 DW_ VSSE NCH W=1U L=0.06U M=1 $name=/N3/N00
M62 YNPASS0 YP0N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I12/N00
M63 VDDPE YP0N YNPASS0 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I12/P00
M64 YPPASS0 YNPASS0 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I1/N00
M65 VDDPE YNPASS0 YPPASS0 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I1/P00
M66 YNPASS1 YP1N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I20/N00
M67 VDDPE YP1N YNPASS1 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I20/P00
M68 YPPASS1 YNPASS1 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I23/N00
M69 VDDPE YNPASS1 YPPASS1 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I23/P00
M7 BL2 YPPASS2 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P21/P00
M70 YNPASS2 YP2N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I24/N00
M71 VDDPE YP2N YNPASS2 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I24/P00
M72 YPPASS2 YNPASS2 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I25/N00
M73 VDDPE YNPASS2 YPPASS2 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I25/P00
M74 YNPASS3 YP3N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I26/N00
M75 VDDPE YP3N YNPASS3 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I26/P00
M76 YPPASS3 YNPASS3 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I27/N00
M77 VDDPE YNPASS3 YPPASS3 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I27/P00
M78 YNPASS4 YP4N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I28/N00
M79 VDDPE YP4N YNPASS4 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I28/P00
M8 BL5 YPPASS5 DR VDDCE PCH W=0.66U L=0.06U M=1 $name=/P38/P00
M80 YPPASS4 YNPASS4 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I29/N00
M81 VDDPE YNPASS4 YPPASS4 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I29/P00
M82 YPPASS5 YNPASS5 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I30/N00
M83 VDDPE YNPASS5 YPPASS5 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I30/P00
M84 YNPASS5 YP5N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I33/N00
M85 VDDPE YP5N YNPASS5 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I33/P00
M86 YPPASS7 YNPASS7 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I34/N00
M87 VDDPE YNPASS7 YPPASS7 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I34/P00
M88 YNPASS7 YP7N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I35/N00
M89 VDDPE YP7N YNPASS7 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I35/P00
M9 BL4_ YPPASS4 DR_ VDDCE PCH W=0.66U L=0.06U M=1 $name=/P42/P00
M90 YNPASS6 YP6N VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I36/N00
M91 VDDPE YP6N YNPASS6 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I36/P00
M92 YPPASS6 YNPASS6 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I39/N00
M93 VDDPE YNPASS6 YPPASS6 VDDCE PCH W=0.25U L=0.06U M=1 $name=/I39/P00
M94 NET284 BTP VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I3/N00
M95 VDDPE BTP NET284 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I3/P00
M96 NET287 BTP VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I93/N00
M97 VDDPE BTP NET287 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I93/P00
M98 PRE0 NET284 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/N38/N00
M99 PRE3 NET287 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/N40/N00
.ENDS lut_sram_1024x16CD8_1B
****
.SUBCKT lut_sram_1024x16CDEDGE BTP DRPREN PG_TERM TIELOW YP0_0 YP0_1 YP0_2
+  YP0_3 YP0_4 YP0_5 YP0_6 YP0_7 VSSE VDDPE VDDCE
** lut_sram_1024x16CDEDGE: 4 flat devices **
M0 VDDCE NET22 NET22 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M1 VDDCE TIELOW NET22 VDDCE PCH W=0.18U L=0.06U M=1 $name=/P0/P00
M2 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M3 TIELOW NET22 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N2/N00
.ENDS lut_sram_1024x16CDEDGE
****
.SUBCKT lut_sram_1024x16CDROWLM016 BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0__0 BL0__1
+  BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11
+  BL0__12 BL0__13 BL0__14 BL0__15 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6
+  BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1__0 BL1__1
+  BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11
+  BL1__12 BL1__13 BL1__14 BL1__15 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6
+  BL2_7 BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2__0 BL2__1
+  BL2__2 BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11
+  BL2__12 BL2__13 BL2__14 BL2__15 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6
+  BL3_7 BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3__0 BL3__1
+  BL3__2 BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BL3__10 BL3__11
+  BL3__12 BL3__13 BL3__14 BL3__15 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6
+  BL4_7 BL4_8 BL4_9 BL4_10 BL4_11 BL4_12 BL4_13 BL4_14 BL4_15 BL4__0 BL4__1
+  BL4__2 BL4__3 BL4__4 BL4__5 BL4__6 BL4__7 BL4__8 BL4__9 BL4__10 BL4__11
+  BL4__12 BL4__13 BL4__14 BL4__15 BL5_0 BL5_1 BL5_2 BL5_3 BL5_4 BL5_5 BL5_6
+  BL5_7 BL5_8 BL5_9 BL5_10 BL5_11 BL5_12 BL5_13 BL5_14 BL5_15 BL5__0 BL5__1
+  BL5__2 BL5__3 BL5__4 BL5__5 BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11
+  BL5__12 BL5__13 BL5__14 BL5__15 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6
+  BL6_7 BL6_8 BL6_9 BL6_10 BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6__0 BL6__1
+  BL6__2 BL6__3 BL6__4 BL6__5 BL6__6 BL6__7 BL6__8 BL6__9 BL6__10 BL6__11
+  BL6__12 BL6__13 BL6__14 BL6__15 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6
+  BL7_7 BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7__0 BL7__1
+  BL7__2 BL7__3 BL7__4 BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11
+  BL7__12 BL7__13 BL7__14 BL7__15 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5
+  DR_6 DR_7 DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2
+  DR__3 DR__4 DR__5 DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13
+  DR__14 DR__15 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11
+  DW_12 DW_13 DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7
+  DW__8 DW__9 DW__10 DW__11 DW__12 DW__13 DW__14 DW__15 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7
+  GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 TIELOW YP0_0N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
** lut_sram_1024x16CDROWLM016: 1604 flat devices **
XCD8_1B1 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BL4_0 BL4__0
+  BL5_0 BL5__0 BL6_0 BL6__0 BL7_0 BL7__0 BTP DR_0 DRPREN DR__0 DW_0 DW__0
+  GDL_0 GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B10 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BL4_9 BL4__9
+  BL5_9 BL5__9 BL6_9 BL6__9 BL7_9 BL7__9 BTP DR_9 DRPREN DR__9 DW_9 DW__9
+  GDL_9 GDL__9 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B11 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BL4_10
+  BL4__10 BL5_10 BL5__10 BL6_10 BL6__10 BL7_10 BL7__10 BTP DR_10 DRPREN
+  DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B12 BL0_11 BL0__11 BL1_11 BL1__11 BL2_11 BL2__11 BL3_11 BL3__11 BL4_11
+  BL4__11 BL5_11 BL5__11 BL6_11 BL6__11 BL7_11 BL7__11 BTP DR_11 DRPREN
+  DR__11 DW_11 DW__11 GDL_11 GDL__11 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B13 BL0_12 BL0__12 BL1_12 BL1__12 BL2_12 BL2__12 BL3_12 BL3__12 BL4_12
+  BL4__12 BL5_12 BL5__12 BL6_12 BL6__12 BL7_12 BL7__12 BTP DR_12 DRPREN
+  DR__12 DW_12 DW__12 GDL_12 GDL__12 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B14 BL0_13 BL0__13 BL1_13 BL1__13 BL2_13 BL2__13 BL3_13 BL3__13 BL4_13
+  BL4__13 BL5_13 BL5__13 BL6_13 BL6__13 BL7_13 BL7__13 BTP DR_13 DRPREN
+  DR__13 DW_13 DW__13 GDL_13 GDL__13 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B15 BL0_14 BL0__14 BL1_14 BL1__14 BL2_14 BL2__14 BL3_14 BL3__14 BL4_14
+  BL4__14 BL5_14 BL5__14 BL6_14 BL6__14 BL7_14 BL7__14 BTP DR_14 DRPREN
+  DR__14 DW_14 DW__14 GDL_14 GDL__14 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B16 BL0_15 BL0__15 BL1_15 BL1__15 BL2_15 BL2__15 BL3_15 BL3__15 BL4_15
+  BL4__15 BL5_15 BL5__15 BL6_15 BL6__15 BL7_15 BL7__15 BTP DR_15 DRPREN
+  DR__15 DW_15 DW__15 GDL_15 GDL__15 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B2 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BL4_1 BL4__1
+  BL5_1 BL5__1 BL6_1 BL6__1 BL7_1 BL7__1 BTP DR_1 DRPREN DR__1 DW_1 DW__1
+  GDL_1 GDL__1 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B3 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BL4_2 BL4__2
+  BL5_2 BL5__2 BL6_2 BL6__2 BL7_2 BL7__2 BTP DR_2 DRPREN DR__2 DW_2 DW__2
+  GDL_2 GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B4 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BL4_3 BL4__3
+  BL5_3 BL5__3 BL6_3 BL6__3 BL7_3 BL7__3 BTP DR_3 DRPREN DR__3 DW_3 DW__3
+  GDL_3 GDL__3 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B5 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BL4_4 BL4__4
+  BL5_4 BL5__4 BL6_4 BL6__4 BL7_4 BL7__4 BTP DR_4 DRPREN DR__4 DW_4 DW__4
+  GDL_4 GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B6 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BL4_5 BL4__5
+  BL5_5 BL5__5 BL6_5 BL6__5 BL7_5 BL7__5 BTP DR_5 DRPREN DR__5 DW_5 DW__5
+  GDL_5 GDL__5 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B7 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BL4_6 BL4__6
+  BL5_6 BL5__6 BL6_6 BL6__6 BL7_6 BL7__6 BTP DR_6 DRPREN DR__6 DW_6 DW__6
+  GDL_6 GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B8 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BL4_7 BL4__7
+  BL5_7 BL5__7 BL6_7 BL6__7 BL7_7 BL7__7 BTP DR_7 DRPREN DR__7 DW_7 DW__7
+  GDL_7 GDL__7 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B9 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BL4_8 BL4__8
+  BL5_8 BL5__8 BL6_8 BL6__8 BL7_8 BL7__8 BTP DR_8 DRPREN DR__8 DW_8 DW__8
+  GDL_8 GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XI128 BTP DRPREN VSSE TIELOW YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CDEDGE
.ENDS lut_sram_1024x16CDROWLM016
****
.SUBCKT lut_sram_1024x16XP_1B ATRACK0 ATRACK0B ATRACK0T ATRACK1 ATRACK1B
+  ATRACK1T ATRACK2 ATRACK2B ATRACK2T ATRACK3 ATRACK3B ATRACK3T ATRACK4
+  ATRACK4B ATRACK4T ATRACK5 ATRACK5B ATRACK5T AX5N AX5NIN BTPCDT BTPSA BTPSAN
+  BTPT BTPTN BTPWN BTPWNN DRPRENT PDRPRET PG_TERM RET SAEN SAENN STUBMATCH0
+  STUBMATCH1 STUBMATCH2 STUBMATCH3 TIEHIGHB TIEHIGHT TIELOW XP0 XP0_ XP1 XP1_
+  XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ YP0_0T YP0_1T YP0_2T YP0_3T YP0_4T
+  YP0_5T YP0_6T YP0_7T VSSE VDDPE VDDCE
** lut_sram_1024x16XP_1B: 126 flat devices **
M0 VDDPE A2_ NET409 VDDCE PCH W=1.1U L=0.06U M=1 $name=/txppnand/P00
M1 VDDPE A4 NET394 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P9/P00
M10 VDDPE AI0_ NET439 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P28/P00
M100 XP5_ NET461 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I54/N00
M101 VDDPE NET461 XP5_ VDDCE PCH W=4U L=0.06U M=1 $name=/I54/P00
M102 NET520 ATRACK4 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I45/N00
M103 VDDPE ATRACK4 NET520 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I45/P00
M104 SAEN SAENN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I44/N00
M105 VDDPE SAENN SAEN VDDCE PCH W=10.02U L=0.06U M=1 $name=/I44/P00
M106 NET524 AX5NIN VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I42/N00
M107 VDDPE AX5NIN NET524 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I42/P00
M108 BTPT BTPTN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I40/N00
M109 VDDPE BTPTN BTPT VDDCE PCH W=10.02U L=0.06U M=1 $name=/I40/P00
M11 VDDPE A1 NET448 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P25/P00
M110 XP5 NET394 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I39/N00
M111 VDDPE NET394 XP5 VDDCE PCH W=4U L=0.06U M=1 $name=/I39/P00
M112 XP0_ NET439 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I35/N00
M113 VDDPE NET439 XP0_ VDDCE PCH W=4U L=0.06U M=1 $name=/I35/P00
M114 NET532 ATRACK2 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I34/N00
M115 VDDPE ATRACK2 NET532 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I34/P00
M116 XP0 NET346 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I33/N00
M117 VDDPE NET346 XP0 VDDCE PCH W=4U L=0.06U M=1 $name=/I33/P00
M118 XP1 NET358 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I31/N00
M119 VDDPE NET358 XP1 VDDCE PCH W=4U L=0.06U M=1 $name=/I31/P00
M12 VDDPE AI0 NET358 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P24/P00
M120 NET493 ATRACK1 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I30/N00
M121 VDDPE ATRACK1 NET493 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I30/P00
M122 NET489 ATRACK0 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/I29/N00
M123 VDDPE ATRACK0 NET489 VDDCE PCH W=0.38U L=0.06U M=1 $name=/I29/P00
M124 XP2_ NET457 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I28/N00
M125 VDDPE NET457 XP2_ VDDCE PCH W=4U L=0.06U M=1 $name=/I28/P00
M13 VDDPE A1 NET358 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P23/P00
M14 VDDPE AI0_ NET448 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P22/P00
M15 VDDPE A4 NET343 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P2/P00
M16 VDDPE A3_ NET457 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P19/P00
M17 VDDPE A2 NET373 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P18/P00
M18 VDDPE A3_ NET373 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P17/P00
M19 VDDPE A2_ NET457 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P16/P00
M2 NET425 A5_ VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P8/P00
M20 NET461 A5 VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P15/P00
M21 NET461 A4_ VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P14/P00
M22 VDDPE A3 NET409 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P13/P00
M23 VDDPE A2 NET391 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P12/P00
M24 VDDPE A3 NET391 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P11/P00
M25 VDDPE A5 NET394 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P10/P00
M26 VSSE RET DRPRENT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N24/N00
M27 VSSE RET BTPT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N9/N00
M28 VSSE RET BTPCDT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N6/N00
M29 VSSE RET BTPSA VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M3 VDDPE TIEHIGHB TIEHIGHB VDDCE PCH W=0.15U L=0.06U M=1 $name=/P57/P00
M30 NET413 A2_ NET409 VSSE NCH W=1.72U L=0.06U M=1 $name=/txpnnand/N00
M31 NET413 A2 NET391 VSSE NCH W=1.72U L=0.06U M=1 $name=/N8/N00
M32 NET413 A3 VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N7/N00
M33 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N60/N00
M34 TIELOW TIEHIGHB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N59/N00
M35 NET425 A4_ NET431 VSSE NCH W=1.72U L=0.06U M=1 $name=/N5/N00
M36 NET431 A5_ VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N4/N00
M37 NET431 A4 NET343 VSSE NCH W=1.72U L=0.06U M=1 $name=/N3/N00
M38 NET434 AI0 NET346 VSSE NCH W=1.72U L=0.06U M=1 $name=/N23/N00
M39 NET434 A1_ VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N22/N00
M4 VDDPE TIELOW TIEHIGHB VDDCE PCH W=4.8U L=0.06U M=1 $name=/P56/P00
M40 NET434 AI0_ NET439 VSSE NCH W=1.72U L=0.06U M=1 $name=/N21/N00
M41 NET443 AI0 NET358 VSSE NCH W=1.72U L=0.06U M=1 $name=/N18/N00
M42 NET443 A1 VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N17/N00
M43 NET443 AI0_ NET448 VSSE NCH W=1.72U L=0.06U M=1 $name=/N16/N00
M44 NET452 A2 NET373 VSSE NCH W=1.72U L=0.06U M=1 $name=/N13/N00
M45 NET452 A3_ VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N12/N00
M46 NET452 A2_ NET457 VSSE NCH W=1.72U L=0.06U M=1 $name=/N11/N00
M47 NET461 A4_ NET467 VSSE NCH W=1.72U L=0.06U M=1 $name=/N10/N00
M48 NET467 A5 VSSE VSSE NCH W=1.72U L=0.06U M=1 $name=/N1/N00
M49 NET467 A4 NET394 VSSE NCH W=1.72U L=0.06U M=1 $name=/N0/N00
M5 NET425 A4_ VDDPE VDDCE PCH W=1.1U L=0.06U M=1 $name=/P4/P00
M50 DRPRENT NET469 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I1/N00
M51 VDDPE NET469 DRPRENT VDDCE PCH W=10.02U L=0.06U M=1 $name=/I1/P00
M52 NET469 PDRPRET VSSE VSSE NCH W=3.6U L=0.06U M=1 $name=/I4/N00
M53 VDDPE PDRPRET NET469 VDDCE PCH W=5U L=0.06U M=1 $name=/I4/P00
M54 NET472 ATRACK3 VSSE VSSE NCH W=0.28U L=0.06U M=1 $name=/tinvain/N00
M55 VDDPE ATRACK3 NET472 VDDCE PCH W=0.38U L=0.06U M=1 $name=/tinvain/P00
M56 A3_ NET472 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/tinvaidd/N00
M57 VDDPE NET472 A3_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/tinvaidd/P00
M58 A3 ATRACK3 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/tinvai/N00
M59 VDDPE ATRACK3 A3 VDDCE PCH W=1.12U L=0.06U M=1 $name=/tinvai/P00
M6 VDDPE A1_ NET439 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P31/P00
M60 BTPWN BTPWNN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpwnl/N00
M61 VDDPE BTPWNN BTPWN VDDCE PCH W=10.02U L=0.06U M=1 $name=/tbtpwnl/P00
M62 BTPSA BTPSAN VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsal/N00
M63 VDDPE BTPSAN BTPSA VDDCE PCH W=10.02U L=0.06U M=1 $name=/tbtpsal/P00
M64 BTPCDT NET469 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpcdl/N00
M65 VDDPE NET469 BTPCDT VDDCE PCH W=10.02U L=0.06U M=1 $name=/tbtpcdl/P00
M66 XP3 NET391 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/apdrv/N00
M67 VDDPE NET391 XP3 VDDCE PCH W=4U L=0.06U M=1 $name=/apdrv/P00
M68 TIEHIGHT TIELOW VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I96/N00
M69 VDDPE TIELOW TIEHIGHT VDDCE PCH W=4.8U L=0.06U M=1 $name=/I96/P00
M7 VDDPE AI0 NET346 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P30/P00
M70 AI0_ NET489 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I81/N00
M71 VDDPE NET489 AI0_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I81/P00
M72 AI0 ATRACK0 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I80/N00
M73 VDDPE ATRACK0 AI0 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I80/P00
M74 A1_ NET493 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I79/N00
M75 VDDPE NET493 A1_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I79/P00
M76 A1 ATRACK1 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I78/N00
M77 VDDPE ATRACK1 A1 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I78/P00
M78 A2_ NET532 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I77/N00
M79 VDDPE NET532 A2_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I77/P00
M8 VDDPE A5_ NET343 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P3/P00
M80 A2 ATRACK2 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I76/N00
M81 VDDPE ATRACK2 A2 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I76/P00
M82 XP1_ NET448 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I63/N00
M83 VDDPE NET448 XP1_ VDDCE PCH W=4U L=0.06U M=1 $name=/I63/P00
M84 XP2 NET373 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I62/N00
M85 VDDPE NET373 XP2 VDDCE PCH W=4U L=0.06U M=1 $name=/I62/P00
M86 A4_ NET520 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I61/N00
M87 VDDPE NET520 A4_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I61/P00
M88 XP3_ NET409 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I60/N00
M89 VDDPE NET409 XP3_ VDDCE PCH W=4U L=0.06U M=1 $name=/I60/P00
M9 VDDPE A1_ NET346 VDDCE PCH W=1.1U L=0.06U M=1 $name=/P29/P00
M90 A4 ATRACK4 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I59/N00
M91 VDDPE ATRACK4 A4 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I59/P00
M92 XP4_ NET425 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I58/N00
M93 VDDPE NET425 XP4_ VDDCE PCH W=4U L=0.06U M=1 $name=/I58/P00
M94 XP4 NET343 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I57/N00
M95 VDDPE NET343 XP4 VDDCE PCH W=4U L=0.06U M=1 $name=/I57/P00
M96 A5_ NET524 VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I56/N00
M97 VDDPE NET524 A5_ VDDCE PCH W=1.12U L=0.06U M=1 $name=/I56/P00
M98 A5 AX5NIN VSSE VSSE NCH W=0.82U L=0.06U M=1 $name=/I55/N00
M99 VDDPE AX5NIN A5 VDDCE PCH W=1.12U L=0.06U M=1 $name=/I55/P00
.ENDS lut_sram_1024x16XP_1B
****
.SUBCKT lut_sram_1024x16APY_1B AX5N AY0N AY0NB AY0NT AY1N AY1NB AY1NT AY2N
+  AY2NB AY2NT BSTN BTPT2_TERM BTPT3_TERM BTPWDT0 BTPWDT1 PBTPSA PBTPSAT
+  PBTPWN PDRPRET PSAEN RET RRBTPT RXP0 RXP1 RXP2 RXP3 YP0_0NT YP0_1NT YP0_2NT
+  YP0_3NT YP0_4NT YP0_5NT YP0_6NT YP0_7NT VSSE VDDPE VDDCE
** lut_sram_1024x16APY_1B: 130 flat devices **
M0 BST AIND7T_ YP7T VDDCE PCH W=2U L=0.06U M=1 $name=/tppass/P00
M1 BST AIND0T_ YP0T VDDCE PCH W=2U L=0.06U M=1 $name=/P44/P00
M10 YP1T AIND1T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N62/N00
M100 YP0_1NT YP1T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I66/N00
M101 VDDPE YP1T YP0_1NT VDDCE PCH W=8U L=0.06U M=1 $name=/I66/P00
M102 NET383 AIND6T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I65/N00
M103 VDDPE AIND6T_ NET383 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I65/P00
M104 YP0_6NT YP6T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I29/N00
M105 VDDPE YP6T YP0_6NT VDDCE PCH W=8U L=0.06U M=1 $name=/I29/P00
M106 NET524 AY0N VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I179/N00
M107 VDDPE AY0N NET524 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I179/P00
M108 NET519 NET524 VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/I178/N00
M109 VDDPE NET524 NET519 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I178/P00
M11 YP0T AIND0T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N61/N00
M110 AI0 NET519 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I177/N00
M111 VDDPE NET519 AI0 VDDCE PCH W=1.8U L=0.06U M=1 $name=/I177/P00
M112 AI0_ NET524 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I175/N00
M113 VDDPE NET524 AI0_ VDDCE PCH W=1.8U L=0.06U M=1 $name=/I175/P00
M114 AI1_ NET527 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I173/N00
M115 VDDPE NET527 AI1_ VDDCE PCH W=1.8U L=0.06U M=1 $name=/I173/P00
M116 NET527 AY1N VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I172/N00
M117 VDDPE AY1N NET527 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I172/P00
M118 AI1 NET485 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I171/N00
M119 VDDPE NET485 AI1 VDDCE PCH W=1.8U L=0.06U M=1 $name=/I171/P00
M12 YP2T AIND2T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N60/N00
M120 YP0_2NT YP2T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I144/N00
M121 VDDPE YP2T YP0_2NT VDDCE PCH W=8U L=0.06U M=1 $name=/I144/P00
M122 YP0_3NT YP3T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I143/N00
M123 VDDPE YP3T YP0_3NT VDDCE PCH W=8U L=0.06U M=1 $name=/I143/P00
M124 YP0_4NT YP4T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I142/N00
M125 VDDPE YP4T YP0_4NT VDDCE PCH W=8U L=0.06U M=1 $name=/I142/P00
M126 YP0_5NT YP5T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I141/N00
M127 VDDPE YP5T YP0_5NT VDDCE PCH W=8U L=0.06U M=1 $name=/I141/P00
M128 AI2 NET487 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I1/N00
M129 VDDPE NET487 AI2 VDDCE PCH W=1.8U L=0.06U M=1 $name=/I1/P00
M13 YP3T AIND3T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N59/N00
M14 YP4T AIND4T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N58/N00
M15 YP5T AIND5T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N57/N00
M16 YP6T AIND6T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N56/N00
M17 YP1T NET497 BST VSSE NCH W=2U L=0.06U M=1 $name=/N55/N00
M18 YP0T NET365 BST VSSE NCH W=2U L=0.06U M=1 $name=/N54/N00
M19 YP2T NET368 BST VSSE NCH W=2U L=0.06U M=1 $name=/N53/N00
M2 BST AIND1T_ YP1T VDDCE PCH W=2U L=0.06U M=1 $name=/P43/P00
M20 YP3T NET503 BST VSSE NCH W=2U L=0.06U M=1 $name=/N52/N00
M21 YP5T NET505 BST VSSE NCH W=2U L=0.06U M=1 $name=/N51/N00
M22 YP4T NET377 BST VSSE NCH W=2U L=0.06U M=1 $name=/N50/N00
M23 YP6T NET383 BST VSSE NCH W=2U L=0.06U M=1 $name=/N49/N00
M24 HNET166 AI2 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gypselnand/N02
M25 HNET167 AI1 HNET166 VSSE NCH W=0.8U L=0.06U M=1 $name=/gypselnand/N01
M26 AIND7T_ AI0 HNET167 VSSE NCH W=0.8U L=0.06U M=1 $name=/gypselnand/N00
M27 VDDPE AI2 AIND7T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/gypselnand/P20
M28 VDDPE AI1 AIND7T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/gypselnand/P10
M29 VDDPE AI0 AIND7T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/gypselnand/P00
M3 BST AIND2T_ YP2T VDDCE PCH W=2U L=0.06U M=1 $name=/P42/P00
M30 HNET173 AI2_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I77/N02
M31 HNET174 AI1_ HNET173 VSSE NCH W=0.8U L=0.06U M=1 $name=/I77/N01
M32 AIND1T_ AI0 HNET174 VSSE NCH W=0.8U L=0.06U M=1 $name=/I77/N00
M33 VDDPE AI2_ AIND1T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I77/P20
M34 VDDPE AI1_ AIND1T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I77/P10
M35 VDDPE AI0 AIND1T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I77/P00
M36 HNET180 AI2_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I76/N02
M37 HNET181 AI1_ HNET180 VSSE NCH W=0.8U L=0.06U M=1 $name=/I76/N01
M38 AIND0T_ AI0_ HNET181 VSSE NCH W=0.8U L=0.06U M=1 $name=/I76/N00
M39 VDDPE AI2_ AIND0T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I76/P20
M4 BST AIND3T_ YP3T VDDCE PCH W=2U L=0.06U M=1 $name=/P41/P00
M40 VDDPE AI1_ AIND0T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I76/P10
M41 VDDPE AI0_ AIND0T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I76/P00
M42 HNET187 AI2_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I73/N02
M43 HNET188 AI1 HNET187 VSSE NCH W=0.8U L=0.06U M=1 $name=/I73/N01
M44 AIND2T_ AI0_ HNET188 VSSE NCH W=0.8U L=0.06U M=1 $name=/I73/N00
M45 VDDPE AI2_ AIND2T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I73/P20
M46 VDDPE AI1 AIND2T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I73/P10
M47 VDDPE AI0_ AIND2T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I73/P00
M48 HNET194 AI2_ VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I72/N02
M49 HNET195 AI1 HNET194 VSSE NCH W=0.8U L=0.06U M=1 $name=/I72/N01
M5 BST AIND5T_ YP5T VDDCE PCH W=2U L=0.06U M=1 $name=/P40/P00
M50 AIND3T_ AI0 HNET195 VSSE NCH W=0.8U L=0.06U M=1 $name=/I72/N00
M51 VDDPE AI2_ AIND3T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I72/P20
M52 VDDPE AI1 AIND3T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I72/P10
M53 VDDPE AI0 AIND3T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I72/P00
M54 HNET201 AI2 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I69/N02
M55 HNET202 AI1_ HNET201 VSSE NCH W=0.8U L=0.06U M=1 $name=/I69/N01
M56 AIND4T_ AI0_ HNET202 VSSE NCH W=0.8U L=0.06U M=1 $name=/I69/N00
M57 VDDPE AI2 AIND4T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I69/P20
M58 VDDPE AI1_ AIND4T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I69/P10
M59 VDDPE AI0_ AIND4T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I69/P00
M6 BST AIND4T_ YP4T VDDCE PCH W=2U L=0.06U M=1 $name=/P39/P00
M60 HNET208 AI2 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I68/N02
M61 HNET209 AI1_ HNET208 VSSE NCH W=0.8U L=0.06U M=1 $name=/I68/N01
M62 AIND5T_ AI0 HNET209 VSSE NCH W=0.8U L=0.06U M=1 $name=/I68/N00
M63 VDDPE AI2 AIND5T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I68/P20
M64 VDDPE AI1_ AIND5T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I68/P10
M65 VDDPE AI0 AIND5T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I68/P00
M66 HNET215 AI2 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I62/N02
M67 HNET216 AI1 HNET215 VSSE NCH W=0.8U L=0.06U M=1 $name=/I62/N01
M68 AIND6T_ AI0_ HNET216 VSSE NCH W=0.8U L=0.06U M=1 $name=/I62/N00
M69 VDDPE AI2 AIND6T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I62/P20
M7 BST AIND6T_ YP6T VDDCE PCH W=2U L=0.06U M=1 $name=/P38/P00
M70 VDDPE AI1 AIND6T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I62/P10
M71 VDDPE AI0_ AIND6T_ VDDCE PCH W=0.4U L=0.06U M=1 $name=/I62/P00
M72 NET490 AY2N VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/taininv/N00
M73 VDDPE AY2N NET490 VDDCE PCH W=0.6U L=0.06U M=1 $name=/taininv/P00
M74 NET485 NET527 VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/tain1/N00
M75 VDDPE NET527 NET485 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tain1/P00
M76 NET487 NET490 VSSE VSSE NCH W=0.25U L=0.06U M=1 $name=/tain/N00
M77 VDDPE NET490 NET487 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tain/P00
M78 AI2_ NET490 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/taidrv/N00
M79 VDDPE NET490 AI2_ VDDCE PCH W=1.8U L=0.06U M=1 $name=/taidrv/P00
M8 YP7T AIND7T_ VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tnypdesel/N00
M80 NET491 AIND7T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gypselinv/N00
M81 VDDPE AIND7T_ NET491 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gypselinv/P00
M82 BST BSTN VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gbkselinv/N00
M83 VDDPE BSTN BST VDDCE PCH W=4U L=0.06U M=1 $name=/gbkselinv/P00
M84 YP0_7NT YP7T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/gapydrv/N00
M85 VDDPE YP7T YP0_7NT VDDCE PCH W=8U L=0.06U M=1 $name=/gapydrv/P00
M86 NET497 AIND1T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I79/N00
M87 VDDPE AIND1T_ NET497 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I79/P00
M88 NET365 AIND0T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I78/N00
M89 VDDPE AIND0T_ NET365 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I78/P00
M9 YP7T NET491 BST VSSE NCH W=2U L=0.06U M=1 $name=/tnpass/N00
M90 NET368 AIND2T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I75/N00
M91 VDDPE AIND2T_ NET368 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I75/P00
M92 NET503 AIND3T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I74/N00
M93 VDDPE AIND3T_ NET503 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I74/P00
M94 NET505 AIND5T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I71/N00
M95 VDDPE AIND5T_ NET505 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I71/P00
M96 NET377 AIND4T_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I70/N00
M97 VDDPE AIND4T_ NET377 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I70/P00
M98 YP0_0NT YP0T VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I67/N00
M99 VDDPE YP0T YP0_0NT VDDCE PCH W=8U L=0.06U M=1 $name=/I67/P00
.ENDS lut_sram_1024x16APY_1B
****
.SUBCKT lut_sram_1024x16CK_1B AX5N AX6NB AXIN BS0N BS1 BS1IN BS1N BS2 BS2IN
+  BS2N BSTN BTPCDTR BTPSAR BTPSATR BTPWDT0 BTPWDT1 BTPWNR DRPRENTR GTP GTPB
+  GTPD GTPDB GTPDE GTPDET GTPDT GTPT LGWEN MBL MGDLE MGDLET MGDLS MGDLST
+  MGTPE MGTPET MGTPS MGTPST MWLLATE PBTPSAL PBTPSATL PBTPWNL PDRPRETL PG_TERM
+  PSAENL RDT RET RREN RRENB RRENT SAENR TIEHIGH TIELOW WBTDD YP0_0T YP0_1T
+  YP0_2T YP0_3T YP0_4T YP0_5T YP0_6T YP0_7T VSSE VDDPE VDDCE
** lut_sram_1024x16CK_1B: 159 flat devices **
M0 BLKSELT NET503 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I53/N10
M1 BLKSELT NET464 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I53/N00
M10 VDDPE RDT HNET124 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnr2t/P01
M100 VDDPE BLKSELT BLKSELTN VDDCE PCH W=0.22U L=0.06U M=1 $name=/I50/P00
M101 NET475 NET470 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I35/N00
M102 VDDPE NET470 NET475 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I35/P00
M103 GTPNT_WDT GTPT_WDT VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/I8/N00
M104 VDDPE GTPT_WDT GTPNT_WDT VDDCE PCH W=1.6U L=0.06U M=1 $name=/I8/P00
M105 BTPWDT1 GTPNT_WDT VSSE VSSE NCH W=2.49U L=0.06U M=1 $name=/I9/N00
M106 VDDPE GTPNT_WDT BTPWDT1 VDDCE PCH W=6U L=0.06U M=1 $name=/I9/P00
M107 BS2 BS2N VSSE VSSE NCH W=0.16U L=0.06U M=1 $name=/I65/N00
M108 VDDPE BS2N BS2 VDDCE PCH W=0.22U L=0.06U M=1 $name=/I65/P00
M109 BS1 BS1N VSSE VSSE NCH W=0.16U L=0.06U M=1 $name=/I57/N00
M11 HNET124 NET493 NET328 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnr2t/P00
M110 VDDPE BS1N BS1 VDDCE PCH W=0.22U L=0.06U M=1 $name=/I57/P00
M111 NET526 NET464 VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/I55/N00
M112 VDDPE NET464 NET526 VDDCE PCH W=0.42U L=0.06U M=1 $name=/I55/P00
M113 NET493 BS0N VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/I48/N00
M114 VDDPE BS0N NET493 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I48/P00
M115 NET495 NET458 VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I6/N00
M116 VDDPE NET458 NET495 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I6/P00
M117 NET497 NET498 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I4/N00
M118 VDDPE NET498 NET497 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I4/P00
M119 BLKSELTNT NET325 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I51/N00
M12 RSELT LGWE2 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/tnr2prebtpsa/N10
M120 VDDPE NET325 BLKSELTNT VDDCE PCH W=0.22U L=0.06U M=1 $name=/I51/P00
M121 NET501 RREN VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/tsaseti/N00
M122 VDDPE RREN NET501 VDDCE PCH W=1U L=0.06U M=1 $name=/tsaseti/P00
M123 NET503 AXIN VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/I56/N00
M124 VDDPE AXIN NET503 VDDCE PCH W=0.42U L=0.06U M=1 $name=/I56/P00
M125 SASELN SASEL VSSE VSSE NCH W=0.64U L=0.06U M=1 $name=/tinv2/N00
M126 VDDPE SASEL SASELN VDDCE PCH W=0.86U L=0.06U M=1 $name=/tinv2/P00
M127 SASEL NET473 VSSE VSSE NCH W=0.54U L=0.06U M=1 $name=/tinv1/N00
M128 VDDPE NET473 SASEL VDDCE PCH W=0.73U L=0.06U M=1 $name=/tinv1/P00
M129 NET477 NET475 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I36/N00
M13 RSELT NET493 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/tnr2prebtpsa/N00
M130 VDDPE NET475 NET477 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I36/P00
M131 LGWE2 LGWEN VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/tbtpwninva/N00
M132 VDDPE LGWEN LGWE2 VDDCE PCH W=1.5U L=0.06U M=1 $name=/tbtpwninva/P00
M133 BTPWNR PBTPWNL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpwn/N00
M134 VDDPE PBTPWNL BTPWNR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpwn/P00
M135 GTPNT_WD GTPT_WD VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/tbtpwdn/N00
M136 VDDPE GTPT_WD GTPNT_WD VDDCE PCH W=1.6U L=0.06U M=1 $name=/tbtpwdn/P00
M137 BTPWDT0 GTPNT_WD VSSE VSSE NCH W=2.49U L=0.06U M=1 $name=/tbtpwd/N00
M138 VDDPE GTPNT_WD BTPWDT0 VDDCE PCH W=6U L=0.06U M=1 $name=/tbtpwd/P00
M139 BTPSATR PBTPSATL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsatr/N00
M14 VDDPE LGWE2 HNET129 VDDCE PCH W=1.4U L=0.06U M=1 $name=/tnr2prebtpsa/P01
M140 VDDPE PBTPSATL BTPSATR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpsatr/P00
M141 LGWEND LGWE2 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tbtpsapredrv6/N00
M142 VDDPE LGWE2 LGWEND VDDCE PCH W=1.4U L=0.06U M=1 $name=/tbtpsapredrv6/P00
M143 SAENR PSAENL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsaen/N00
M144 VDDPE PSAENL SAENR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpsaen/P00
M145 BTPSAR PBTPSAL VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpsa/N00
M146 VDDPE PBTPSAL BTPSAR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpsa/P00
M147 BTPCDTR CDPRET VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tbtpcd/N00
M148 VDDPE CDPRET BTPCDTR VDDCE PCH W=10U L=0.06U M=1 $name=/tbtpcd/P00
M149 BSTN NET526 VSSE VSSE NCH W=1.24U L=0.06U M=1 $name=/tbkselt2n/N00
M15 HNET129 NET493 RSELT VDDCE PCH W=1.4U L=0.06U M=1 $name=/tnr2prebtpsa/P00
M150 VDDPE NET526 BSTN VDDCE PCH W=1.68U L=0.06U M=1 $name=/tbkselt2n/P00
M151 NET527 NET497 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I5/N00
M152 VDDPE NET497 NET527 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I5/P00
M153 DRPRENTR CDPRET VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I207/N00
M154 VDDPE CDPRET DRPRENTR VDDCE PCH W=10U L=0.06U M=1 $name=/I207/P00
M155 CDPRET PDRPRETL VSSE VSSE NCH W=3.6U L=0.06U M=1 $name=/I205/N00
M156 VDDPE PDRPRETL CDPRET VDDCE PCH W=5U L=0.06U M=1 $name=/I205/P00
M157 NET474 RDT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I191/N00
M158 VDDPE RDT NET474 VDDCE PCH W=0.2U L=0.06U M=1 $name=/I191/P00
M16 HNET137 GTP_CDSA VSSE VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N11
M17 PBTPSATL RSELT HNET137 VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N10
M18 HNET135 GTP_CDSA VSSE VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N01
M19 PBTPSATL RSELT HNET135 VSSE NCH W=1.16U L=0.06U M=1 $name=/tynand2/N00
M2 VDDPE NET503 HNET114 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I53/P01
M20 VDDPE GTP_CDSA PBTPSATL VDDCE PCH W=1.5U L=0.06U M=1 $name=/tynand2/P10
M21 VDDPE RSELT PBTPSATL VDDCE PCH W=1.5U L=0.06U M=1 $name=/tynand2/P00
M22 HNET142 NET498 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/tnd2t/N11
M23 PDRPRETL NET527 HNET142 VSSE NCH W=1.25U L=0.06U M=1 $name=/tnd2t/N10
M24 HNET140 NET498 VSSE VSSE NCH W=1.25U L=0.06U M=1 $name=/tnd2t/N01
M25 PDRPRETL NET527 HNET140 VSSE NCH W=1.25U L=0.06U M=1 $name=/tnd2t/N00
M26 VDDPE NET498 PDRPRETL VDDCE PCH W=2.5U L=0.06U M=1 $name=/tnd2t/P10
M27 VDDPE NET527 PDRPRETL VDDCE PCH W=2.5U L=0.06U M=1 $name=/tnd2t/P00
M28 HNET147 LGWEND VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N11
M29 PBTPSAL GTP_CDSA HNET147 VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N10
M3 HNET114 NET464 BLKSELT VDDCE PCH W=0.3U L=0.06U M=1 $name=/I53/P00
M30 HNET145 LGWEND VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N01
M31 PBTPSAL GTP_CDSA HNET145 VSSE NCH W=2.28U L=0.06U M=1 $name=/tbtpsapredrvnd2/N00
M32 VDDPE LGWEND PBTPSAL VDDCE PCH W=2.7U L=0.06U M=1 $name=/tbtpsapredrvnd2/P10
M33 VDDPE GTP_CDSA PBTPSAL VDDCE PCH W=2.7U L=0.06U M=1 $name=/tbtpsapredrvnd2/P00
M34 GTPT_WDT BLKSELTNT GTP VDDCE PCH W=0.6U L=0.06U M=1 $name=/P0/P00
M35 GTPT_WD BLKSELTN GTP VDDCE PCH W=0.6U L=0.06U M=1 $name=/twdpgp/P00
M36 PSAENL NET352 NET353 VDDCE PCH W=5.2U L=0.06U M=1 $name=/tsasetp2/P00
M37 NET353 PBTPSAL PSAENL VDDCE PCH W=6U L=0.06U M=1 $name=/tsasetp1/P00
M38 VDDPE NET501 NET353 VDDCE PCH W=6U L=0.06U M=1 $name=/tsasetp/P00
M39 GTP_CDSA SASELN GTP VDDCE PCH W=4.98U L=0.06U M=1 $name=/tpp/P00
M4 NET325 AXIN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I54/N10
M40 VDDPE MGDLE VDDPE VDDCE PCH W=0.2U L=0.06U M=1 $name=/tpcapgdlload/P00
M41 VDDPE TIELOW TIEHIGH VDDCE PCH W=5.01U L=0.06U M=1 $name=/P8/P00
M42 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P3/P00
M43 VDDPE MGDLS VDDPE VDDCE PCH W=0.2U L=0.06U M=1 $name=/P2/P00
M44 VDDPE GTPDE VDDPE VDDCE PCH W=1.46U L=0.06U M=1 $name=/P10/P00
M45 GTPT_WDT NET325 GTP VSSE NCH W=0.6U L=0.06U M=1 $name=/N16/N00
M46 GTPT_WDT BLKSELTNT VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/N18/N00
M47 NET387 NET352 VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/N11/N00
M48 PSAENL PBTPSAL NET393 VSSE NCH W=1.86U L=0.06U M=1 $name=/N3/N00
M49 NET393 NET352 VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/N5/N00
M5 NET325 NET464 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I54/N00
M50 PSAENL PBTPSAL NET387 VSSE NCH W=1.86U L=0.06U M=1 $name=/N10/N00
M51 GTPT_WD BLKSELT GTP VSSE NCH W=0.6U L=0.06U M=1 $name=/twdpgn/N00
M52 NET402 NET352 VSSE VSSE NCH W=1.86U L=0.06U M=1 $name=/tsasetn2/N00
M53 PSAENL NET501 VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/tsasetn1/N00
M54 PSAENL PBTPSAL NET402 VSSE NCH W=1.86U L=0.06U M=1 $name=/tsasetn/N00
M55 GTP SASEL GTP_CDSA VSSE NCH W=4.98U L=0.06U M=1 $name=/tpn/N00
M56 MGDLE TIELOW VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tpdcapgdlload/N00
M57 GTP_CDSA SASELN VSSE VSSE NCH W=2.66U L=0.06U M=1 $name=/tpd/N00
M58 VSSE MGDLE VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tncapgdlload/N00
M59 GTPT_WD BLKSELTN VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/tdwdkpn/N00
M6 VDDPE AXIN HNET119 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I54/P01
M60 VSSE GTPDE VSSE VSSE NCH W=2.12U L=0.06U M=1 $name=/N23/N00
M61 VSSE MGDLS VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N22/N00
M62 TIELOW TIEHIGH VSSE VSSE NCH W=3U L=0.06U M=1 $name=/N20/N00
M63 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N2/N00
M64 MGDLS TIELOW VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N15/N00
M65 VSSE RET BTPWDT1 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N19/N00
M66 VSSE RET BTPSAR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N9/N00
M67 VSSE RET BTPSATR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N8/N00
M68 VSSE RET BTPCDTR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N7/N00
M69 VSSE RET BTPWDT0 VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N6/N00
M7 HNET119 NET464 NET325 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I54/P00
M70 VSSE RET DRPRENTR VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N17/N00
M71 HNET262 NET470 VSSE VSSE NCH W=2.1U L=0.06U M=1 $name=/I31/N01
M72 PBTPWNL NET477 HNET262 VSSE NCH W=2.1U L=0.06U M=1 $name=/I31/N00
M73 VDDPE NET470 PBTPWNL VDDCE PCH W=2.9U L=0.06U M=1 $name=/I31/P10
M74 VDDPE NET477 PBTPWNL VDDCE PCH W=2.9U L=0.06U M=1 $name=/I31/P00
M75 HNET266 BS2IN VSSE VSSE NCH W=0.21U L=0.06U M=1 $name=/I67/N01
M76 NET458 BS1IN HNET266 VSSE NCH W=0.21U L=0.06U M=1 $name=/I67/N00
M77 VDDPE BS2IN NET458 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I67/P10
M78 VDDPE BS1IN NET458 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I67/P00
M79 HNET270 NET328 VSSE VSSE NCH W=0.51U L=0.06U M=1 $name=/tynand/N01
M8 NET328 RDT VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tnr2t/N10
M80 NET498 GTP_CDSA HNET270 VSSE NCH W=0.51U L=0.06U M=1 $name=/tynand/N00
M81 VDDPE NET328 NET498 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tynand/P10
M82 VDDPE GTP_CDSA NET498 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tynand/P00
M83 HNET274 BS0N VSSE VSSE NCH W=0.68U L=0.06U M=1 $name=/tnbst/N01
M84 NET464 NET495 HNET274 VSSE NCH W=0.68U L=0.06U M=1 $name=/tnbst/N00
M85 VDDPE BS0N NET464 VDDCE PCH W=0.46U L=0.06U M=1 $name=/tnbst/P10
M86 VDDPE NET495 NET464 VDDCE PCH W=0.46U L=0.06U M=1 $name=/tnbst/P00
M87 HNET278 GTPD VSSE VSSE NCH W=1.28U L=0.06U M=1 $name=/tgnd2lat/N01
M88 NET352 PSAENL HNET278 VSSE NCH W=1.28U L=0.06U M=1 $name=/tgnd2lat/N00
M89 VDDPE GTPD NET352 VDDCE PCH W=0.88U L=0.06U M=1 $name=/tgnd2lat/P10
M9 NET328 NET493 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/tnr2t/N00
M90 VDDPE PSAENL NET352 VDDCE PCH W=0.88U L=0.06U M=1 $name=/tgnd2lat/P00
M91 HNET282 LGWE2 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/tbtpwnnd2/N01
M92 NET470 GTP_CDSA HNET282 VSSE NCH W=0.9U L=0.06U M=1 $name=/tbtpwnnd2/N00
M93 VDDPE LGWE2 NET470 VDDCE PCH W=0.8U L=0.06U M=1 $name=/tbtpwnnd2/P10
M94 VDDPE GTP_CDSA NET470 VDDCE PCH W=0.8U L=0.06U M=1 $name=/tbtpwnnd2/P00
M95 HNET286 NET474 VSSE VSSE NCH W=0.21U L=0.06U M=1 $name=/tbtpsnd2/N01
M96 NET473 NET495 HNET286 VSSE NCH W=0.21U L=0.06U M=1 $name=/tbtpsnd2/N00
M97 VDDPE NET474 NET473 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tbtpsnd2/P10
M98 VDDPE NET495 NET473 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tbtpsnd2/P00
M99 BLKSELTN BLKSELT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I50/N00
.ENDS lut_sram_1024x16CK_1B
****
.SUBCKT lut_sram_1024x16LOCDEC_SBB0B ATRACK0B ATRACK0T ATRACK1B ATRACK1T
+  ATRACK2B ATRACK2T ATRACK3B ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T
+  AX6NB AY0NB AY0NT AY1NB AY1NT AY2NB AY2NT BS0N BS1N BTPCDT BTPCDTR BTPSA
+  BTPSAR BTPSATR BTPT BTPT2_TERM BTPT3_TERM BTPWDT0 BTPWDT1 BTPWN BTPWNR
+  DRPRENT DRPRENTR GTPDB GTPDET GTPDT GTPT LGWEN MBL MGTPET MGTPST MWLLATE
+  PG_TERM_0 PG_TERM_1 RDT RET RRENB RRENT RXP0 RXP1 RXP2 RXP3 SAEN SAENR
+  TIEHIGHT TIELOW WBTDD XP0 XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_
+  YP0_0T YP0_1T YP0_2T YP0_3T YP0_4T YP0_5T YP0_6T YP0_7T VSSE VDDPE VDDCE
** lut_sram_1024x16LOCDEC_SBB0B: 415 flat devices **
XI0 ATRACK0B ATRACK0B ATRACK0T ATRACK1B ATRACK1B ATRACK1T ATRACK2B ATRACK2B
+  ATRACK2T ATRACK3B ATRACK3B ATRACK3T ATRACK4B ATRACK4B ATRACK4T ATRACK5B
+  ATRACK5B ATRACK5T ATRACK5B AX5NIN BTPCDT BTPSA BTPSAN BTPT BTPTN BTPWN
+  BTPWNN DRPRENT PDRPRET PG_TERM_1 RET SAEN SAENN TIELOW TIELOW TIELOW TIELOW
+  AX5NIN TIEHIGHT TIELOW XP0 XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5
+  XP5_ YP0_0T YP0_1T YP0_2T YP0_3T YP0_4T YP0_5T YP0_6T YP0_7T VSSE VDDPE
+  VDDCE lut_sram_1024x16XP_1B
XI1 ATRACK5B AY0NB AY0NB AY0NT AY1NB AY1NB AY1NT AY2NB AY2NB AY2NT BSTN
+  BTPT2_TERM BTPT3_TERM BTPWDT0 BTPWDT1 BTPSAN BTPTN BTPWNN PDRPRET SAENN RET
+  VSSE RXP0 RXP1 RXP2 RXP3 YP0_0T YP0_1T YP0_2T YP0_3T YP0_4T YP0_5T YP0_6T
+  YP0_7T VSSE VDDPE VDDCE lut_sram_1024x16APY_1B
XI2 ATRACK5B AX6NB ATRACK5B BS0N BS1 BS1N BS1N BS2 AX6NB AX6NB BSTN BTPCDTR
+  BTPSAR BTPSATR BTPWDT0 BTPWDT1 BTPWNR DRPRENTR GTPT GTPT GTPDB GTPDB GTPDB
+  GTPDET GTPDT GTPT LGWEN MBL GTPDET GTPDET GTPDET GTPDET MGTPET MGTPET
+  MGTPST MGTPST MWLLATE BTPSAN BTPTN BTPWNN PDRPRET PG_TERM_0 SAENN RDT RET
+  RRENB RRENB RRENT SAENR TIEHIGH GTPDET WBTDD YP0_0T YP0_1T YP0_2T YP0_3T
+  YP0_4T YP0_5T YP0_6T YP0_7T VSSE VDDPE VDDCE lut_sram_1024x16CK_1B
.ENDS lut_sram_1024x16LOCDEC_SBB0B
****
.SUBCKT lut_sram_1024x16SA8_1B BTPSA BTPT BTPWN DRT DRT_ DW DW_ GDL GDLB GDLB_
+  GDL_ SAEN VSSE VDDPE VDDCE
** lut_sram_1024x16SA8_1B: 45 flat devices **
M0 VDDPE GDL NET0166 VDDCE PCH W=0.24U L=0.06U M=1 $name=/P14/P00
M1 NET0166 BTPWN NET87 VDDCE PCH W=0.24U L=0.06U M=1 $name=/P15/P00
M10 NET0140 BTPWN NET90 VDDCE PCH W=0.24U L=0.06U M=1 $name=/P1/P00
M11 VDDPE SD SD_ VDDCE PCH W=0.2U L=0.06U M=1 $name=/tsdpu/P00
M12 SI SD NET22 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tqbufp/P00
M13 SD SAENB VDDPE VDDCE PCH W=0.3U L=0.06U M=1 $name=/tpresd/P00
M14 DRT BTPTLB SD VDDCE PCH W=1.1U L=0.06U M=1 $name=/tdracc/P00
M15 SD_ SAENB SD VDDCE PCH W=0.3U L=0.06U M=1 $name=/P9/P00
M16 VDDPE SAENB SD_ VDDCE PCH W=0.3U L=0.06U M=1 $name=/P8/P00
M17 NET22 BTPSA VDDPE VDDCE PCH W=0.7U L=0.06U M=1 $name=/P63/P00
M18 DRT_ BTPTLB SD_ VDDCE PCH W=1.1U L=0.06U M=1 $name=/P5/P00
M19 SD SD_ VDDPE VDDCE PCH W=0.2U L=0.06U M=1 $name=/P13/P00
M2 VDDPE BTPSA NET0153 VDDCE PCH W=0.35U L=0.06U M=1 $name=/P10/P00
M20 SI_ SD_ NET22 VDDCE PCH W=0.5U L=0.06U M=1 $name=/P0/P00
M21 VDDPE GDL_ NET0140 VDDCE PCH W=0.24U L=0.06U M=1 $name=/tpprea/P00
M22 SE SAEN VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N8/N00
M23 SE BTPSA VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N9/N00
M24 NET90 GDL_ VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/tnpreb/N00
M25 NET90 BTPWN VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N0/N00
M26 NET87 GDL VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N7/N00
M27 SD_ SD SRC VSSE NCH W=4U L=0.17U M=1 $name=/tsdpd/N00
M28 VSSE BTPSA SI VSSE NCH W=0.13U L=0.06U M=1 $name=/tqbufn/N00
M29 VSSE SE SRC VSSE NCH W=4U L=0.17U M=1 $name=/tnpdsrc/N00
M3 NET0153 SAEN SE VDDCE PCH W=0.35U L=0.06U M=1 $name=/P12/P00
M30 GDL SI VSSE VSSE NCH W=2.8U L=0.06U M=1 $name=/tgdldrvn/N00
M31 NET87 BTPWN VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N4/N00
M32 VSSE SD SI VSSE NCH W=0.18U L=0.06U M=1 $name=/N67/N00
M33 GDL_ SI_ VSSE VSSE NCH W=2.8U L=0.06U M=1 $name=/N6/N00
M34 SRC SD_ SD VSSE NCH W=4U L=0.17U M=1 $name=/N5/N00
M35 SI_ SD_ VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N3/N00
M36 SI_ BTPSA VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/N2/N00
M37 BTPTLB BTPT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tinvbtptlb/N00
M38 VDDPE BTPT BTPTLB VDDCE PCH W=0.21U L=0.06U M=1 $name=/tinvbtptlb/P00
M39 DW NET87 VSSE VSSE NCH W=1.18U L=0.06U M=1 $name=/gdwt/N00
M4 VDDPE BTPSA NET0153 VDDCE PCH W=0.35U L=0.06U M=1 $name=/P11/P00
M40 VDDPE NET87 DW VDDCE PCH W=0.3U L=0.06U M=1 $name=/gdwt/P00
M41 DW_ NET90 VSSE VSSE NCH W=1.18U L=0.06U M=1 $name=/I39/N00
M42 VDDPE NET90 DW_ VDDCE PCH W=0.3U L=0.06U M=1 $name=/I39/P00
M43 SAENB SAEN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I17/N00
M44 VDDPE SAEN SAENB VDDCE PCH W=0.15U L=0.06U M=1 $name=/I17/P00
M5 NET0169 BTPWN NET90 VDDCE PCH W=0.24U L=0.06U M=1 $name=/P17/P00
M6 VDDPE GDL_ NET0169 VDDCE PCH W=0.24U L=0.06U M=1 $name=/P16/P00
M7 NET0145 BTPWN NET87 VDDCE PCH W=0.24U L=0.06U M=1 $name=/P2/P00
M8 VDDPE GDL NET0145 VDDCE PCH W=0.24U L=0.06U M=1 $name=/P6/P00
M9 NET0153 SAEN SE VDDCE PCH W=0.35U L=0.06U M=1 $name=/P7/P00
.ENDS lut_sram_1024x16SA8_1B
****
.SUBCKT lut_sram_1024x16BSAROW16R BTPSA BTPT BTPWN DRT_0 DRT_1 DRT_2 DRT_3
+  DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT_10 DRT_11 DRT_12 DRT_13 DRT_14
+  DRT_15 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8
+  DRT__9 DRT__10 DRT__11 DRT__12 DRT__13 DRT__14 DRT__15 DW_0 DW_1 DW_2 DW_3
+  DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15 DW__0
+  DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11 DW__12
+  DW__13 DW__14 DW__15 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6
+  GDLB_7 GDLB_8 GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15
+  GDLB__0 GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8
+  GDLB__9 GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14 GDLB__15 SAEN VSSE
+  VDDPE VDDCE
** lut_sram_1024x16BSAROW16R: 720 flat devices **
XSA8_1B1 BTPSA BTPT BTPWN DRT_0 DRT__0 DW_0 DW__0 GDLB_0 GDLB_0 GDLB__0
+  GDLB__0 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B10 BTPSA BTPT BTPWN DRT_9 DRT__9 DW_9 DW__9 GDLB_9 GDLB_9 GDLB__9
+  GDLB__9 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B11 BTPSA BTPT BTPWN DRT_10 DRT__10 DW_10 DW__10 GDLB_10 GDLB_10
+  GDLB__10 GDLB__10 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B12 BTPSA BTPT BTPWN DRT_11 DRT__11 DW_11 DW__11 GDLB_11 GDLB_11
+  GDLB__11 GDLB__11 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B13 BTPSA BTPT BTPWN DRT_12 DRT__12 DW_12 DW__12 GDLB_12 GDLB_12
+  GDLB__12 GDLB__12 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B14 BTPSA BTPT BTPWN DRT_13 DRT__13 DW_13 DW__13 GDLB_13 GDLB_13
+  GDLB__13 GDLB__13 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B15 BTPSA BTPT BTPWN DRT_14 DRT__14 DW_14 DW__14 GDLB_14 GDLB_14
+  GDLB__14 GDLB__14 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B16 BTPSA BTPT BTPWN DRT_15 DRT__15 DW_15 DW__15 GDLB_15 GDLB_15
+  GDLB__15 GDLB__15 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B2 BTPSA BTPT BTPWN DRT_1 DRT__1 DW_1 DW__1 GDLB_1 GDLB_1 GDLB__1
+  GDLB__1 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B3 BTPSA BTPT BTPWN DRT_2 DRT__2 DW_2 DW__2 GDLB_2 GDLB_2 GDLB__2
+  GDLB__2 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B4 BTPSA BTPT BTPWN DRT_3 DRT__3 DW_3 DW__3 GDLB_3 GDLB_3 GDLB__3
+  GDLB__3 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B5 BTPSA BTPT BTPWN DRT_4 DRT__4 DW_4 DW__4 GDLB_4 GDLB_4 GDLB__4
+  GDLB__4 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B6 BTPSA BTPT BTPWN DRT_5 DRT__5 DW_5 DW__5 GDLB_5 GDLB_5 GDLB__5
+  GDLB__5 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B7 BTPSA BTPT BTPWN DRT_6 DRT__6 DW_6 DW__6 GDLB_6 GDLB_6 GDLB__6
+  GDLB__6 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B8 BTPSA BTPT BTPWN DRT_7 DRT__7 DW_7 DW__7 GDLB_7 GDLB_7 GDLB__7
+  GDLB__7 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B9 BTPSA BTPT BTPWN DRT_8 DRT__8 DW_8 DW__8 GDLB_8 GDLB_8 GDLB__8
+  GDLB__8 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
.ENDS lut_sram_1024x16BSAROW16R
****
.SUBCKT lut_sram_1024x16BSAROW16L BTPSA BTPT BTPWN DRT_0 DRT_1 DRT_2 DRT_3
+  DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT_10 DRT_11 DRT_12 DRT_13 DRT_14
+  DRT_15 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8
+  DRT__9 DRT__10 DRT__11 DRT__12 DRT__13 DRT__14 DRT__15 DW_0 DW_1 DW_2 DW_3
+  DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15 DW__0
+  DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11 DW__12
+  DW__13 DW__14 DW__15 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6
+  GDLB_7 GDLB_8 GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15
+  GDLB__0 GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8
+  GDLB__9 GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14 GDLB__15 SAEN VSSE
+  VDDPE VDDCE
** lut_sram_1024x16BSAROW16L: 720 flat devices **
XSA8_1B1 BTPSA BTPT BTPWN DRT_0 DRT__0 DW_0 DW__0 GDLB_0 GDLB_0 GDLB__0
+  GDLB__0 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B10 BTPSA BTPT BTPWN DRT_9 DRT__9 DW_9 DW__9 GDLB_9 GDLB_9 GDLB__9
+  GDLB__9 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B11 BTPSA BTPT BTPWN DRT_10 DRT__10 DW_10 DW__10 GDLB_10 GDLB_10
+  GDLB__10 GDLB__10 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B12 BTPSA BTPT BTPWN DRT_11 DRT__11 DW_11 DW__11 GDLB_11 GDLB_11
+  GDLB__11 GDLB__11 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B13 BTPSA BTPT BTPWN DRT_12 DRT__12 DW_12 DW__12 GDLB_12 GDLB_12
+  GDLB__12 GDLB__12 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B14 BTPSA BTPT BTPWN DRT_13 DRT__13 DW_13 DW__13 GDLB_13 GDLB_13
+  GDLB__13 GDLB__13 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B15 BTPSA BTPT BTPWN DRT_14 DRT__14 DW_14 DW__14 GDLB_14 GDLB_14
+  GDLB__14 GDLB__14 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B16 BTPSA BTPT BTPWN DRT_15 DRT__15 DW_15 DW__15 GDLB_15 GDLB_15
+  GDLB__15 GDLB__15 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B2 BTPSA BTPT BTPWN DRT_1 DRT__1 DW_1 DW__1 GDLB_1 GDLB_1 GDLB__1
+  GDLB__1 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B3 BTPSA BTPT BTPWN DRT_2 DRT__2 DW_2 DW__2 GDLB_2 GDLB_2 GDLB__2
+  GDLB__2 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B4 BTPSA BTPT BTPWN DRT_3 DRT__3 DW_3 DW__3 GDLB_3 GDLB_3 GDLB__3
+  GDLB__3 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B5 BTPSA BTPT BTPWN DRT_4 DRT__4 DW_4 DW__4 GDLB_4 GDLB_4 GDLB__4
+  GDLB__4 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B6 BTPSA BTPT BTPWN DRT_5 DRT__5 DW_5 DW__5 GDLB_5 GDLB_5 GDLB__5
+  GDLB__5 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B7 BTPSA BTPT BTPWN DRT_6 DRT__6 DW_6 DW__6 GDLB_6 GDLB_6 GDLB__6
+  GDLB__6 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B8 BTPSA BTPT BTPWN DRT_7 DRT__7 DW_7 DW__7 GDLB_7 GDLB_7 GDLB__7
+  GDLB__7 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
XSA8_1B9 BTPSA BTPT BTPWN DRT_8 DRT__8 DW_8 DW__8 GDLB_8 GDLB_8 GDLB__8
+  GDLB__8 SAEN VSSE VDDPE VDDCE lut_sram_1024x16SA8_1B
.ENDS lut_sram_1024x16BSAROW16L
****
.SUBCKT lut_sram_1024x16CDROWRM016 BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0__0 BL0__1
+  BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11
+  BL0__12 BL0__13 BL0__14 BL0__15 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6
+  BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1__0 BL1__1
+  BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11
+  BL1__12 BL1__13 BL1__14 BL1__15 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6
+  BL2_7 BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2__0 BL2__1
+  BL2__2 BL2__3 BL2__4 BL2__5 BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11
+  BL2__12 BL2__13 BL2__14 BL2__15 BL3_0 BL3_1 BL3_2 BL3_3 BL3_4 BL3_5 BL3_6
+  BL3_7 BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13 BL3_14 BL3_15 BL3__0 BL3__1
+  BL3__2 BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BL3__10 BL3__11
+  BL3__12 BL3__13 BL3__14 BL3__15 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6
+  BL4_7 BL4_8 BL4_9 BL4_10 BL4_11 BL4_12 BL4_13 BL4_14 BL4_15 BL4__0 BL4__1
+  BL4__2 BL4__3 BL4__4 BL4__5 BL4__6 BL4__7 BL4__8 BL4__9 BL4__10 BL4__11
+  BL4__12 BL4__13 BL4__14 BL4__15 BL5_0 BL5_1 BL5_2 BL5_3 BL5_4 BL5_5 BL5_6
+  BL5_7 BL5_8 BL5_9 BL5_10 BL5_11 BL5_12 BL5_13 BL5_14 BL5_15 BL5__0 BL5__1
+  BL5__2 BL5__3 BL5__4 BL5__5 BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11
+  BL5__12 BL5__13 BL5__14 BL5__15 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6
+  BL6_7 BL6_8 BL6_9 BL6_10 BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6__0 BL6__1
+  BL6__2 BL6__3 BL6__4 BL6__5 BL6__6 BL6__7 BL6__8 BL6__9 BL6__10 BL6__11
+  BL6__12 BL6__13 BL6__14 BL6__15 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5 BL7_6
+  BL7_7 BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7__0 BL7__1
+  BL7__2 BL7__3 BL7__4 BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11
+  BL7__12 BL7__13 BL7__14 BL7__15 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5
+  DR_6 DR_7 DR_8 DR_9 DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2
+  DR__3 DR__4 DR__5 DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13
+  DR__14 DR__15 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11
+  DW_12 DW_13 DW_14 DW_15 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7
+  DW__8 DW__9 DW__10 DW__11 DW__12 DW__13 DW__14 DW__15 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7
+  GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 TIELOW YP0_0N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
** lut_sram_1024x16CDROWRM016: 1604 flat devices **
XCD8_1B1 BL0_0 BL0__0 BL1_0 BL1__0 BL2_0 BL2__0 BL3_0 BL3__0 BL4_0 BL4__0
+  BL5_0 BL5__0 BL6_0 BL6__0 BL7_0 BL7__0 BTP DR_0 DRPREN DR__0 DW_0 DW__0
+  GDL_0 GDL__0 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B10 BL0_9 BL0__9 BL1_9 BL1__9 BL2_9 BL2__9 BL3_9 BL3__9 BL4_9 BL4__9
+  BL5_9 BL5__9 BL6_9 BL6__9 BL7_9 BL7__9 BTP DR_9 DRPREN DR__9 DW_9 DW__9
+  GDL_9 GDL__9 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B11 BL0_10 BL0__10 BL1_10 BL1__10 BL2_10 BL2__10 BL3_10 BL3__10 BL4_10
+  BL4__10 BL5_10 BL5__10 BL6_10 BL6__10 BL7_10 BL7__10 BTP DR_10 DRPREN
+  DR__10 DW_10 DW__10 GDL_10 GDL__10 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B12 BL0_11 BL0__11 BL1_11 BL1__11 BL2_11 BL2__11 BL3_11 BL3__11 BL4_11
+  BL4__11 BL5_11 BL5__11 BL6_11 BL6__11 BL7_11 BL7__11 BTP DR_11 DRPREN
+  DR__11 DW_11 DW__11 GDL_11 GDL__11 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B13 BL0_12 BL0__12 BL1_12 BL1__12 BL2_12 BL2__12 BL3_12 BL3__12 BL4_12
+  BL4__12 BL5_12 BL5__12 BL6_12 BL6__12 BL7_12 BL7__12 BTP DR_12 DRPREN
+  DR__12 DW_12 DW__12 GDL_12 GDL__12 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B14 BL0_13 BL0__13 BL1_13 BL1__13 BL2_13 BL2__13 BL3_13 BL3__13 BL4_13
+  BL4__13 BL5_13 BL5__13 BL6_13 BL6__13 BL7_13 BL7__13 BTP DR_13 DRPREN
+  DR__13 DW_13 DW__13 GDL_13 GDL__13 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B15 BL0_14 BL0__14 BL1_14 BL1__14 BL2_14 BL2__14 BL3_14 BL3__14 BL4_14
+  BL4__14 BL5_14 BL5__14 BL6_14 BL6__14 BL7_14 BL7__14 BTP DR_14 DRPREN
+  DR__14 DW_14 DW__14 GDL_14 GDL__14 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B16 BL0_15 BL0__15 BL1_15 BL1__15 BL2_15 BL2__15 BL3_15 BL3__15 BL4_15
+  BL4__15 BL5_15 BL5__15 BL6_15 BL6__15 BL7_15 BL7__15 BTP DR_15 DRPREN
+  DR__15 DW_15 DW__15 GDL_15 GDL__15 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N
+  YP0_4N YP0_5N YP0_6N YP0_7N YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N
+  YP0_0N VSSE VDDPE VDDCE lut_sram_1024x16CD8_1B
XCD8_1B2 BL0_1 BL0__1 BL1_1 BL1__1 BL2_1 BL2__1 BL3_1 BL3__1 BL4_1 BL4__1
+  BL5_1 BL5__1 BL6_1 BL6__1 BL7_1 BL7__1 BTP DR_1 DRPREN DR__1 DW_1 DW__1
+  GDL_1 GDL__1 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B3 BL0_2 BL0__2 BL1_2 BL1__2 BL2_2 BL2__2 BL3_2 BL3__2 BL4_2 BL4__2
+  BL5_2 BL5__2 BL6_2 BL6__2 BL7_2 BL7__2 BTP DR_2 DRPREN DR__2 DW_2 DW__2
+  GDL_2 GDL__2 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B4 BL0_3 BL0__3 BL1_3 BL1__3 BL2_3 BL2__3 BL3_3 BL3__3 BL4_3 BL4__3
+  BL5_3 BL5__3 BL6_3 BL6__3 BL7_3 BL7__3 BTP DR_3 DRPREN DR__3 DW_3 DW__3
+  GDL_3 GDL__3 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B5 BL0_4 BL0__4 BL1_4 BL1__4 BL2_4 BL2__4 BL3_4 BL3__4 BL4_4 BL4__4
+  BL5_4 BL5__4 BL6_4 BL6__4 BL7_4 BL7__4 BTP DR_4 DRPREN DR__4 DW_4 DW__4
+  GDL_4 GDL__4 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B6 BL0_5 BL0__5 BL1_5 BL1__5 BL2_5 BL2__5 BL3_5 BL3__5 BL4_5 BL4__5
+  BL5_5 BL5__5 BL6_5 BL6__5 BL7_5 BL7__5 BTP DR_5 DRPREN DR__5 DW_5 DW__5
+  GDL_5 GDL__5 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B7 BL0_6 BL0__6 BL1_6 BL1__6 BL2_6 BL2__6 BL3_6 BL3__6 BL4_6 BL4__6
+  BL5_6 BL5__6 BL6_6 BL6__6 BL7_6 BL7__6 BTP DR_6 DRPREN DR__6 DW_6 DW__6
+  GDL_6 GDL__6 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B8 BL0_7 BL0__7 BL1_7 BL1__7 BL2_7 BL2__7 BL3_7 BL3__7 BL4_7 BL4__7
+  BL5_7 BL5__7 BL6_7 BL6__7 BL7_7 BL7__7 BTP DR_7 DRPREN DR__7 DW_7 DW__7
+  GDL_7 GDL__7 YP0_7N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_6N YP0_5N YP0_4N YP0_3N YP0_2N YP0_1N YP0_0N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XCD8_1B9 BL0_8 BL0__8 BL1_8 BL1__8 BL2_8 BL2__8 BL3_8 BL3__8 BL4_8 BL4__8
+  BL5_8 BL5__8 BL6_8 BL6__8 BL7_8 BL7__8 BTP DR_8 DRPREN DR__8 DW_8 DW__8
+  GDL_8 GDL__8 YP0_0N YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N
+  YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CD8_1B
XI128 BTP DRPREN VSSE TIELOW YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CDEDGE
.ENDS lut_sram_1024x16CDROWRM016
****
.SUBCKT lut_sram_1024x16CHSBB0_16M16 ATRACK0B ATRACK0T ATRACK1B ATRACK1T
+  ATRACK2B ATRACK2T ATRACK3B ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T
+  AX6NB AY0NB AY0NT AY1NB AY1NT AY2NB AY2NT BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15
+  BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25
+  BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13
+  BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22
+  BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31
+  BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11
+  BL1_12 BL1_13 BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21
+  BL1_22 BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31
+  BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9
+  BL1__10 BL1__11 BL1__12 BL1__13 BL1__14 BL1__15 BL1__16 BL1__17 BL1__18
+  BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24 BL1__25 BL1__26 BL1__27
+  BL1__28 BL1__29 BL1__30 BL1__31 BL2_0 BL2_1 BL2_2 BL2_3 BL2_4 BL2_5 BL2_6
+  BL2_7 BL2_8 BL2_9 BL2_10 BL2_11 BL2_12 BL2_13 BL2_14 BL2_15 BL2_16 BL2_17
+  BL2_18 BL2_19 BL2_20 BL2_21 BL2_22 BL2_23 BL2_24 BL2_25 BL2_26 BL2_27
+  BL2_28 BL2_29 BL2_30 BL2_31 BL2__0 BL2__1 BL2__2 BL2__3 BL2__4 BL2__5
+  BL2__6 BL2__7 BL2__8 BL2__9 BL2__10 BL2__11 BL2__12 BL2__13 BL2__14 BL2__15
+  BL2__16 BL2__17 BL2__18 BL2__19 BL2__20 BL2__21 BL2__22 BL2__23 BL2__24
+  BL2__25 BL2__26 BL2__27 BL2__28 BL2__29 BL2__30 BL2__31 BL3_0 BL3_1 BL3_2
+  BL3_3 BL3_4 BL3_5 BL3_6 BL3_7 BL3_8 BL3_9 BL3_10 BL3_11 BL3_12 BL3_13
+  BL3_14 BL3_15 BL3_16 BL3_17 BL3_18 BL3_19 BL3_20 BL3_21 BL3_22 BL3_23
+  BL3_24 BL3_25 BL3_26 BL3_27 BL3_28 BL3_29 BL3_30 BL3_31 BL3__0 BL3__1
+  BL3__2 BL3__3 BL3__4 BL3__5 BL3__6 BL3__7 BL3__8 BL3__9 BL3__10 BL3__11
+  BL3__12 BL3__13 BL3__14 BL3__15 BL3__16 BL3__17 BL3__18 BL3__19 BL3__20
+  BL3__21 BL3__22 BL3__23 BL3__24 BL3__25 BL3__26 BL3__27 BL3__28 BL3__29
+  BL3__30 BL3__31 BL4_0 BL4_1 BL4_2 BL4_3 BL4_4 BL4_5 BL4_6 BL4_7 BL4_8 BL4_9
+  BL4_10 BL4_11 BL4_12 BL4_13 BL4_14 BL4_15 BL4_16 BL4_17 BL4_18 BL4_19
+  BL4_20 BL4_21 BL4_22 BL4_23 BL4_24 BL4_25 BL4_26 BL4_27 BL4_28 BL4_29
+  BL4_30 BL4_31 BL4__0 BL4__1 BL4__2 BL4__3 BL4__4 BL4__5 BL4__6 BL4__7
+  BL4__8 BL4__9 BL4__10 BL4__11 BL4__12 BL4__13 BL4__14 BL4__15 BL4__16
+  BL4__17 BL4__18 BL4__19 BL4__20 BL4__21 BL4__22 BL4__23 BL4__24 BL4__25
+  BL4__26 BL4__27 BL4__28 BL4__29 BL4__30 BL4__31 BL5_0 BL5_1 BL5_2 BL5_3
+  BL5_4 BL5_5 BL5_6 BL5_7 BL5_8 BL5_9 BL5_10 BL5_11 BL5_12 BL5_13 BL5_14
+  BL5_15 BL5_16 BL5_17 BL5_18 BL5_19 BL5_20 BL5_21 BL5_22 BL5_23 BL5_24
+  BL5_25 BL5_26 BL5_27 BL5_28 BL5_29 BL5_30 BL5_31 BL5__0 BL5__1 BL5__2
+  BL5__3 BL5__4 BL5__5 BL5__6 BL5__7 BL5__8 BL5__9 BL5__10 BL5__11 BL5__12
+  BL5__13 BL5__14 BL5__15 BL5__16 BL5__17 BL5__18 BL5__19 BL5__20 BL5__21
+  BL5__22 BL5__23 BL5__24 BL5__25 BL5__26 BL5__27 BL5__28 BL5__29 BL5__30
+  BL5__31 BL6_0 BL6_1 BL6_2 BL6_3 BL6_4 BL6_5 BL6_6 BL6_7 BL6_8 BL6_9 BL6_10
+  BL6_11 BL6_12 BL6_13 BL6_14 BL6_15 BL6_16 BL6_17 BL6_18 BL6_19 BL6_20
+  BL6_21 BL6_22 BL6_23 BL6_24 BL6_25 BL6_26 BL6_27 BL6_28 BL6_29 BL6_30
+  BL6_31 BL6__0 BL6__1 BL6__2 BL6__3 BL6__4 BL6__5 BL6__6 BL6__7 BL6__8
+  BL6__9 BL6__10 BL6__11 BL6__12 BL6__13 BL6__14 BL6__15 BL6__16 BL6__17
+  BL6__18 BL6__19 BL6__20 BL6__21 BL6__22 BL6__23 BL6__24 BL6__25 BL6__26
+  BL6__27 BL6__28 BL6__29 BL6__30 BL6__31 BL7_0 BL7_1 BL7_2 BL7_3 BL7_4 BL7_5
+  BL7_6 BL7_7 BL7_8 BL7_9 BL7_10 BL7_11 BL7_12 BL7_13 BL7_14 BL7_15 BL7_16
+  BL7_17 BL7_18 BL7_19 BL7_20 BL7_21 BL7_22 BL7_23 BL7_24 BL7_25 BL7_26
+  BL7_27 BL7_28 BL7_29 BL7_30 BL7_31 BL7__0 BL7__1 BL7__2 BL7__3 BL7__4
+  BL7__5 BL7__6 BL7__7 BL7__8 BL7__9 BL7__10 BL7__11 BL7__12 BL7__13 BL7__14
+  BL7__15 BL7__16 BL7__17 BL7__18 BL7__19 BL7__20 BL7__21 BL7__22 BL7__23
+  BL7__24 BL7__25 BL7__26 BL7__27 BL7__28 BL7__29 BL7__30 BL7__31 BS0N BS1N
+  BTPT2_TERM BTPT3_TERM BTPWDT0 BTPWDT1 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4
+  GDLB_5 GDLB_6 GDLB_7 GDLB_8 GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14
+  GDLB_15 GDLB_16 GDLB_17 GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23
+  GDLB_24 GDLB_25 GDLB_26 GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB__0
+  GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8 GDLB__9
+  GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14 GDLB__15 GDLB__16 GDLB__17
+  GDLB__18 GDLB__19 GDLB__20 GDLB__21 GDLB__22 GDLB__23 GDLB__24 GDLB__25
+  GDLB__26 GDLB__27 GDLB__28 GDLB__29 GDLB__30 GDLB__31 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL__0 GDL__1
+  GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11
+  GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20
+  GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29
+  GDL__30 GDL__31 GTPB GTPDB GTPDT LGWEN MBL MGDLE MGTPET MGTPS MWLLATE RDT
+  RET RRENB RRENT RXP0 RXP1 RXP2 RXP3 STUBMATCH0 TIEHIGHT TIELOW_0 TIELOW_1
+  WBTDD XP0 XP0_ XP1 XP1_ XP2 XP2_ XP3 XP3_ XP4 XP4_ XP5 XP5_ VSSE VDDPE
+  VDDCE
** lut_sram_1024x16CHSBB0_16M16: 5063 flat devices **
XLEFTCDROW BL0_15 BL0_14 BL0_13 BL0_12 BL0_11 BL0_10 BL0_9 BL0_8 BL0_7 BL0_6
+  BL0_5 BL0_4 BL0_3 BL0_2 BL0_1 BL0_0 BL0__15 BL0__14 BL0__13 BL0__12 BL0__11
+  BL0__10 BL0__9 BL0__8 BL0__7 BL0__6 BL0__5 BL0__4 BL0__3 BL0__2 BL0__1
+  BL0__0 BL1_15 BL1_14 BL1_13 BL1_12 BL1_11 BL1_10 BL1_9 BL1_8 BL1_7 BL1_6
+  BL1_5 BL1_4 BL1_3 BL1_2 BL1_1 BL1_0 BL1__15 BL1__14 BL1__13 BL1__12 BL1__11
+  BL1__10 BL1__9 BL1__8 BL1__7 BL1__6 BL1__5 BL1__4 BL1__3 BL1__2 BL1__1
+  BL1__0 BL2_15 BL2_14 BL2_13 BL2_12 BL2_11 BL2_10 BL2_9 BL2_8 BL2_7 BL2_6
+  BL2_5 BL2_4 BL2_3 BL2_2 BL2_1 BL2_0 BL2__15 BL2__14 BL2__13 BL2__12 BL2__11
+  BL2__10 BL2__9 BL2__8 BL2__7 BL2__6 BL2__5 BL2__4 BL2__3 BL2__2 BL2__1
+  BL2__0 BL3_15 BL3_14 BL3_13 BL3_12 BL3_11 BL3_10 BL3_9 BL3_8 BL3_7 BL3_6
+  BL3_5 BL3_4 BL3_3 BL3_2 BL3_1 BL3_0 BL3__15 BL3__14 BL3__13 BL3__12 BL3__11
+  BL3__10 BL3__9 BL3__8 BL3__7 BL3__6 BL3__5 BL3__4 BL3__3 BL3__2 BL3__1
+  BL3__0 BL4_15 BL4_14 BL4_13 BL4_12 BL4_11 BL4_10 BL4_9 BL4_8 BL4_7 BL4_6
+  BL4_5 BL4_4 BL4_3 BL4_2 BL4_1 BL4_0 BL4__15 BL4__14 BL4__13 BL4__12 BL4__11
+  BL4__10 BL4__9 BL4__8 BL4__7 BL4__6 BL4__5 BL4__4 BL4__3 BL4__2 BL4__1
+  BL4__0 BL5_15 BL5_14 BL5_13 BL5_12 BL5_11 BL5_10 BL5_9 BL5_8 BL5_7 BL5_6
+  BL5_5 BL5_4 BL5_3 BL5_2 BL5_1 BL5_0 BL5__15 BL5__14 BL5__13 BL5__12 BL5__11
+  BL5__10 BL5__9 BL5__8 BL5__7 BL5__6 BL5__5 BL5__4 BL5__3 BL5__2 BL5__1
+  BL5__0 BL6_15 BL6_14 BL6_13 BL6_12 BL6_11 BL6_10 BL6_9 BL6_8 BL6_7 BL6_6
+  BL6_5 BL6_4 BL6_3 BL6_2 BL6_1 BL6_0 BL6__15 BL6__14 BL6__13 BL6__12 BL6__11
+  BL6__10 BL6__9 BL6__8 BL6__7 BL6__6 BL6__5 BL6__4 BL6__3 BL6__2 BL6__1
+  BL6__0 BL7_15 BL7_14 BL7_13 BL7_12 BL7_11 BL7_10 BL7_9 BL7_8 BL7_7 BL7_6
+  BL7_5 BL7_4 BL7_3 BL7_2 BL7_1 BL7_0 BL7__15 BL7__14 BL7__13 BL7__12 BL7__11
+  BL7__10 BL7__9 BL7__8 BL7__7 BL7__6 BL7__5 BL7__4 BL7__3 BL7__2 BL7__1
+  BL7__0 BTP DRPREN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7 DR_8 DR_9 DR_10
+  DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6
+  DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13 DR__14 DR__15 DW_0 DW_1 DW_2
+  DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15
+  DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11
+  DW__12 DW__13 DW__14 DW__15 GDL_15 GDL_14 GDL_13 GDL_12 GDL_11 GDL_10 GDL_9
+  GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0 GDL__15 GDL__14
+  GDL__13 GDL__12 GDL__11 GDL__10 GDL__9 GDL__8 GDL__7 GDL__6 GDL__5 GDL__4
+  GDL__3 GDL__2 GDL__1 GDL__0 TIELOW_0 YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N
+  YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16CDROWLM016
XLEFTSAROW BTPSA BTPT BTPWN DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7 DR_8 DR_9
+  DR_10 DR_11 DR_12 DR_13 DR_14 DR_15 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5
+  DR__6 DR__7 DR__8 DR__9 DR__10 DR__11 DR__12 DR__13 DR__14 DR__15 DW_0 DW_1
+  DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW_8 DW_9 DW_10 DW_11 DW_12 DW_13 DW_14 DW_15
+  DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 DW__8 DW__9 DW__10 DW__11
+  DW__12 DW__13 DW__14 DW__15 GDLB_15 GDLB_14 GDLB_13 GDLB_12 GDLB_11 GDLB_10
+  GDLB_9 GDLB_8 GDLB_7 GDLB_6 GDLB_5 GDLB_4 GDLB_3 GDLB_2 GDLB_1 GDLB_0
+  GDLB__15 GDLB__14 GDLB__13 GDLB__12 GDLB__11 GDLB__10 GDLB__9 GDLB__8
+  GDLB__7 GDLB__6 GDLB__5 GDLB__4 GDLB__3 GDLB__2 GDLB__1 GDLB__0 SAEN VSSE
+  VDDPE VDDCE lut_sram_1024x16BSAROW16L
XLOCAL_DEC ATRACK0B ATRACK0T ATRACK1B ATRACK1T ATRACK2B ATRACK2T ATRACK3B
+  ATRACK3T ATRACK4B ATRACK4T ATRACK5B ATRACK5T AX6NB AY0NB AY0NT AY1NB AY1NT
+  AY2NB AY2NT BS0N BS1N BTP BTPCDTR BTPSA BTPSAR BTPSATR BTPT BTPT2_TERM
+  BTPT3_TERM BTPWDT0 BTPWDT1 BTPWN BTPWNR DRPREN DRPRENTR GTPDB MGDLE GTPDT
+  GTPB LGWEN MBL MGTPET MGTPS MWLLATE VSSE VSSE RDT RET RRENB RRENT RXP0 RXP1
+  RXP2 RXP3 SAEN SAENR TIEHIGHT STUBMATCH0 WBTDD XP0 XP0_ XP1 XP1_ XP2 XP2_
+  XP3 XP3_ XP4 XP4_ XP5 XP5_ YP0_0N YP0_1N YP0_2N YP0_3N YP0_4N YP0_5N YP0_6N
+  YP0_7N VSSE VDDPE VDDCE lut_sram_1024x16LOCDEC_SBB0B
XRIGHTCDROW BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24
+  BL0_25 BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0__16 BL0__17 BL0__18
+  BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25 BL0__26 BL0__27
+  BL0__28 BL0__29 BL0__30 BL0__31 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21
+  BL1_22 BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31
+  BL1__16 BL1__17 BL1__18 BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24
+  BL1__25 BL1__26 BL1__27 BL1__28 BL1__29 BL1__30 BL1__31 BL2_16 BL2_17
+  BL2_18 BL2_19 BL2_20 BL2_21 BL2_22 BL2_23 BL2_24 BL2_25 BL2_26 BL2_27
+  BL2_28 BL2_29 BL2_30 BL2_31 BL2__16 BL2__17 BL2__18 BL2__19 BL2__20 BL2__21
+  BL2__22 BL2__23 BL2__24 BL2__25 BL2__26 BL2__27 BL2__28 BL2__29 BL2__30
+  BL2__31 BL3_16 BL3_17 BL3_18 BL3_19 BL3_20 BL3_21 BL3_22 BL3_23 BL3_24
+  BL3_25 BL3_26 BL3_27 BL3_28 BL3_29 BL3_30 BL3_31 BL3__16 BL3__17 BL3__18
+  BL3__19 BL3__20 BL3__21 BL3__22 BL3__23 BL3__24 BL3__25 BL3__26 BL3__27
+  BL3__28 BL3__29 BL3__30 BL3__31 BL4_16 BL4_17 BL4_18 BL4_19 BL4_20 BL4_21
+  BL4_22 BL4_23 BL4_24 BL4_25 BL4_26 BL4_27 BL4_28 BL4_29 BL4_30 BL4_31
+  BL4__16 BL4__17 BL4__18 BL4__19 BL4__20 BL4__21 BL4__22 BL4__23 BL4__24
+  BL4__25 BL4__26 BL4__27 BL4__28 BL4__29 BL4__30 BL4__31 BL5_16 BL5_17
+  BL5_18 BL5_19 BL5_20 BL5_21 BL5_22 BL5_23 BL5_24 BL5_25 BL5_26 BL5_27
+  BL5_28 BL5_29 BL5_30 BL5_31 BL5__16 BL5__17 BL5__18 BL5__19 BL5__20 BL5__21
+  BL5__22 BL5__23 BL5__24 BL5__25 BL5__26 BL5__27 BL5__28 BL5__29 BL5__30
+  BL5__31 BL6_16 BL6_17 BL6_18 BL6_19 BL6_20 BL6_21 BL6_22 BL6_23 BL6_24
+  BL6_25 BL6_26 BL6_27 BL6_28 BL6_29 BL6_30 BL6_31 BL6__16 BL6__17 BL6__18
+  BL6__19 BL6__20 BL6__21 BL6__22 BL6__23 BL6__24 BL6__25 BL6__26 BL6__27
+  BL6__28 BL6__29 BL6__30 BL6__31 BL7_16 BL7_17 BL7_18 BL7_19 BL7_20 BL7_21
+  BL7_22 BL7_23 BL7_24 BL7_25 BL7_26 BL7_27 BL7_28 BL7_29 BL7_30 BL7_31
+  BL7__16 BL7__17 BL7__18 BL7__19 BL7__20 BL7__21 BL7__22 BL7__23 BL7__24
+  BL7__25 BL7__26 BL7__27 BL7__28 BL7__29 BL7__30 BL7__31 BTPCDTR DRPRENTR
+  DRT_0 DRT_1 DRT_2 DRT_3 DRT_4 DRT_5 DRT_6 DRT_7 DRT_8 DRT_9 DRT_10 DRT_11
+  DRT_12 DRT_13 DRT_14 DRT_15 DRT__0 DRT__1 DRT__2 DRT__3 DRT__4 DRT__5
+  DRT__6 DRT__7 DRT__8 DRT__9 DRT__10 DRT__11 DRT__12 DRT__13 DRT__14 DRT__15
+  DW_0_176 DW_1_170 DW_2_164 DW_3_158 DW_4_152 DW_5_146 DW_6_140 DW_7_134
+  DW_8_128 DW_9_122 DW_10_116 DW_11_110 DW_12_104 DW_13_98 DW_14_92 DW_15_86
+  DW__0_174 DW__1_172 DW__2_162 DW__3_160 DW__4_150 DW__5_148 DW__6_138
+  DW__7_136 DW__8_126 DW__9_124 DW__10_114 DW__11_112 DW__12_102 DW__13_100
+  DW__14_90 DW__15_88 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL__16 GDL__17
+  GDL__18 GDL__19 GDL__20 GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26
+  GDL__27 GDL__28 GDL__29 GDL__30 GDL__31 TIELOW_1 YP0_0N YP0_1N YP0_2N
+  YP0_3N YP0_4N YP0_5N YP0_6N YP0_7N VSSE VDDPE VDDCE
+  lut_sram_1024x16CDROWRM016
XRIGHTSAROW BTPSAR BTPSATR BTPWNR DRT_0 DRT_1 DRT_2 DRT_3 DRT_4 DRT_5 DRT_6
+  DRT_7 DRT_8 DRT_9 DRT_10 DRT_11 DRT_12 DRT_13 DRT_14 DRT_15 DRT__0 DRT__1
+  DRT__2 DRT__3 DRT__4 DRT__5 DRT__6 DRT__7 DRT__8 DRT__9 DRT__10 DRT__11
+  DRT__12 DRT__13 DRT__14 DRT__15 DW_0_176 DW_1_170 DW_2_164 DW_3_158
+  DW_4_152 DW_5_146 DW_6_140 DW_7_134 DW_8_128 DW_9_122 DW_10_116 DW_11_110
+  DW_12_104 DW_13_98 DW_14_92 DW_15_86 DW__0_174 DW__1_172 DW__2_162
+  DW__3_160 DW__4_150 DW__5_148 DW__6_138 DW__7_136 DW__8_126 DW__9_124
+  DW__10_114 DW__11_112 DW__12_102 DW__13_100 DW__14_90 DW__15_88 GDLB_16
+  GDLB_17 GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23 GDLB_24 GDLB_25
+  GDLB_26 GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB__16 GDLB__17 GDLB__18
+  GDLB__19 GDLB__20 GDLB__21 GDLB__22 GDLB__23 GDLB__24 GDLB__25 GDLB__26
+  GDLB__27 GDLB__28 GDLB__29 GDLB__30 GDLB__31 SAENR VSSE VDDPE VDDCE
+  lut_sram_1024x16BSAROW16R
.ENDS lut_sram_1024x16CHSBB0_16M16
****
.SUBCKT lut_sram_1024x16CC BL BL_ CORED CORED_ GDL PG0 WL VSSE VDDPE VDDCE
** lut_sram_1024x16CC: 6 flat devices **
M0 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M3 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M4 BL WL CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL BL_ VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS lut_sram_1024x16CC
****
.SUBCKT lut_sram_1024x16WRAPPED_CC BL BL_ GDL PG0 WL VSSE VDDPE VDDCE
** lut_sram_1024x16WRAPPED_CC: 6 flat devices **
XI0 BL BL_ CORED CORED_ GDL PG0 WL VSSE VDDPE VDDCE lut_sram_1024x16CC
.ENDS lut_sram_1024x16WRAPPED_CC
****
.SUBCKT lut_sram_1024x16CCEDGE_CCMBL BL CCMBL DIFF GDL NDIFF PDIFF PG0 TL0 WL
+  VSSE VDDPE VDDCE
** lut_sram_1024x16CCEDGE_CCMBL: 6 flat devices **
M0 NET41 NET49 VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M1 NDIFF NET41 NET49 VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M2 NET41 WL DIFF VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
M3 CCMBL TL0 NET49 VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M4 PDIFF NET49 NET41 VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M5 NET49 NET41 VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
.ENDS lut_sram_1024x16CCEDGE_CCMBL
****
.SUBCKT lut_sram_1024x16CC_ROW128LO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25
+  GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55
+  GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65
+  GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75
+  GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85
+  GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95
+  GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105
+  GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114
+  GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123
+  GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3
+  PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14
+  PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24
+  PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34
+  PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44
+  PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54
+  PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64
+  PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74
+  PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84
+  PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94
+  PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104
+  PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113
+  PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122
+  PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL VSSE
+  VDDPE VDDCE
** lut_sram_1024x16CC_ROW128LO: 774 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC100 BL_100 BL__99 GDL_100 PG0_100 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC101 BL_101 BL__100 GDL_101 PG0_101 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC102 BL_102 BL__101 GDL_102 PG0_102 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC103 BL_103 BL__102 GDL_103 PG0_103 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC104 BL_104 BL__103 GDL_104 PG0_104 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC105 BL_105 BL__104 GDL_105 PG0_105 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC106 BL_106 BL__105 GDL_106 PG0_106 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC107 BL_107 BL__106 GDL_107 PG0_107 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC108 BL_108 BL__107 GDL_108 PG0_108 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC109 BL_109 BL__108 GDL_109 PG0_109 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC110 BL_110 BL__109 GDL_110 PG0_110 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC111 BL_111 BL__110 GDL_111 PG0_111 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC112 BL_112 BL__111 GDL_112 PG0_112 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC113 BL_113 BL__112 GDL_113 PG0_113 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC114 BL_114 BL__113 GDL_114 PG0_114 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC115 BL_115 BL__114 GDL_115 PG0_115 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC116 BL_116 BL__115 GDL_116 PG0_116 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC117 BL_117 BL__116 GDL_117 PG0_117 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC118 BL_118 BL__117 GDL_118 PG0_118 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC119 BL_119 BL__118 GDL_119 PG0_119 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC120 BL_120 BL__119 GDL_120 PG0_120 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC121 BL_121 BL__120 GDL_121 PG0_121 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC122 BL_122 BL__121 GDL_122 PG0_122 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC123 BL_123 BL__122 GDL_123 PG0_123 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC124 BL_124 BL__123 GDL_124 PG0_124 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC125 BL_125 BL__124 GDL_125 PG0_125 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC126 BL_126 BL__125 GDL_126 PG0_126 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC127 BL_127 BL__126 GDL_127 PG0_127 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC128 BL_128 BL__127 GDL_128 PG0_128 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC45 BL_45 BL__44 GDL_45 PG0_45 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC46 BL_46 BL__45 GDL_46 PG0_46 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC47 BL_47 BL__46 GDL_47 PG0_47 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC48 BL_48 BL__47 GDL_48 PG0_48 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC49 BL_49 BL__48 GDL_49 PG0_49 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC50 BL_50 BL__49 GDL_50 PG0_50 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC51 BL_51 BL__50 GDL_51 PG0_51 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC52 BL_52 BL__51 GDL_52 PG0_52 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC53 BL_53 BL__52 GDL_53 PG0_53 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC54 BL_54 BL__53 GDL_54 PG0_54 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC55 BL_55 BL__54 GDL_55 PG0_55 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC56 BL_56 BL__55 GDL_56 PG0_56 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC57 BL_57 BL__56 GDL_57 PG0_57 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC58 BL_58 BL__57 GDL_58 PG0_58 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC59 BL_59 BL__58 GDL_59 PG0_59 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC60 BL_60 BL__59 GDL_60 PG0_60 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC61 BL_61 BL__60 GDL_61 PG0_61 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC62 BL_62 BL__61 GDL_62 PG0_62 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC63 BL_63 BL__62 GDL_63 PG0_63 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC64 BL_64 BL__63 GDL_64 PG0_64 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC65 BL_65 BL__64 GDL_65 PG0_65 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC66 BL_66 BL__65 GDL_66 PG0_66 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC67 BL_67 BL__66 GDL_67 PG0_67 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC68 BL_68 BL__67 GDL_68 PG0_68 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC69 BL_69 BL__68 GDL_69 PG0_69 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC70 BL_70 BL__69 GDL_70 PG0_70 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC71 BL_71 BL__70 GDL_71 PG0_71 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC72 BL_72 BL__71 GDL_72 PG0_72 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC73 BL_73 BL__72 GDL_73 PG0_73 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC74 BL_74 BL__73 GDL_74 PG0_74 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC75 BL_75 BL__74 GDL_75 PG0_75 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC76 BL_76 BL__75 GDL_76 PG0_76 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC77 BL_77 BL__76 GDL_77 PG0_77 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC78 BL_78 BL__77 GDL_78 PG0_78 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC79 BL_79 BL__78 GDL_79 PG0_79 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC80 BL_80 BL__79 GDL_80 PG0_80 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC81 BL_81 BL__80 GDL_81 PG0_81 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC82 BL_82 BL__81 GDL_82 PG0_82 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC83 BL_83 BL__82 GDL_83 PG0_83 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC84 BL_84 BL__83 GDL_84 PG0_84 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC85 BL_85 BL__84 GDL_85 PG0_85 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC86 BL_86 BL__85 GDL_86 PG0_86 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC87 BL_87 BL__86 GDL_87 PG0_87 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC88 BL_88 BL__87 GDL_88 PG0_88 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC89 BL_89 BL__88 GDL_89 PG0_89 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC90 BL_90 BL__89 GDL_90 PG0_90 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC91 BL_91 BL__90 GDL_91 PG0_91 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC92 BL_92 BL__91 GDL_92 PG0_92 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC93 BL_93 BL__92 GDL_93 PG0_93 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC94 BL_94 BL__93 GDL_94 PG0_94 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC95 BL_95 BL__94 GDL_95 PG0_95 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC96 BL_96 BL__95 GDL_96 PG0_96 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC97 BL_97 BL__96 GDL_97 PG0_97 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC98 BL_98 BL__97 GDL_98 PG0_98 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC99 BL_99 BL__98 GDL_99 PG0_99 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16CC_ROW128LO
****
.SUBCKT lut_sram_1024x16CC_ROW128LE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25
+  GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55
+  GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65
+  GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75
+  GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85
+  GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95
+  GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105
+  GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114
+  GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123
+  GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3
+  PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14
+  PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24
+  PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34
+  PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44
+  PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54
+  PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64
+  PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74
+  PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84
+  PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94
+  PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104
+  PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113
+  PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122
+  PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL VSSE
+  VDDPE VDDCE
** lut_sram_1024x16CC_ROW128LE: 774 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC100 BL_100 BL__99 GDL_100 PG0_100 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC101 BL_101 BL__100 GDL_101 PG0_101 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC102 BL_102 BL__101 GDL_102 PG0_102 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC103 BL_103 BL__102 GDL_103 PG0_103 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC104 BL_104 BL__103 GDL_104 PG0_104 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC105 BL_105 BL__104 GDL_105 PG0_105 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC106 BL_106 BL__105 GDL_106 PG0_106 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC107 BL_107 BL__106 GDL_107 PG0_107 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC108 BL_108 BL__107 GDL_108 PG0_108 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC109 BL_109 BL__108 GDL_109 PG0_109 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC110 BL_110 BL__109 GDL_110 PG0_110 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC111 BL_111 BL__110 GDL_111 PG0_111 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC112 BL_112 BL__111 GDL_112 PG0_112 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC113 BL_113 BL__112 GDL_113 PG0_113 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC114 BL_114 BL__113 GDL_114 PG0_114 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC115 BL_115 BL__114 GDL_115 PG0_115 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC116 BL_116 BL__115 GDL_116 PG0_116 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC117 BL_117 BL__116 GDL_117 PG0_117 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC118 BL_118 BL__117 GDL_118 PG0_118 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC119 BL_119 BL__118 GDL_119 PG0_119 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC120 BL_120 BL__119 GDL_120 PG0_120 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC121 BL_121 BL__120 GDL_121 PG0_121 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC122 BL_122 BL__121 GDL_122 PG0_122 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC123 BL_123 BL__122 GDL_123 PG0_123 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC124 BL_124 BL__123 GDL_124 PG0_124 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC125 BL_125 BL__124 GDL_125 PG0_125 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC126 BL_126 BL__125 GDL_126 PG0_126 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC127 BL_127 BL__126 GDL_127 PG0_127 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC128 BL_128 BL__127 GDL_128 PG0_128 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC45 BL_45 BL__44 GDL_45 PG0_45 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC46 BL_46 BL__45 GDL_46 PG0_46 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC47 BL_47 BL__46 GDL_47 PG0_47 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC48 BL_48 BL__47 GDL_48 PG0_48 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC49 BL_49 BL__48 GDL_49 PG0_49 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC50 BL_50 BL__49 GDL_50 PG0_50 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC51 BL_51 BL__50 GDL_51 PG0_51 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC52 BL_52 BL__51 GDL_52 PG0_52 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC53 BL_53 BL__52 GDL_53 PG0_53 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC54 BL_54 BL__53 GDL_54 PG0_54 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC55 BL_55 BL__54 GDL_55 PG0_55 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC56 BL_56 BL__55 GDL_56 PG0_56 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC57 BL_57 BL__56 GDL_57 PG0_57 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC58 BL_58 BL__57 GDL_58 PG0_58 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC59 BL_59 BL__58 GDL_59 PG0_59 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC60 BL_60 BL__59 GDL_60 PG0_60 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC61 BL_61 BL__60 GDL_61 PG0_61 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC62 BL_62 BL__61 GDL_62 PG0_62 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC63 BL_63 BL__62 GDL_63 PG0_63 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC64 BL_64 BL__63 GDL_64 PG0_64 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC65 BL_65 BL__64 GDL_65 PG0_65 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC66 BL_66 BL__65 GDL_66 PG0_66 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC67 BL_67 BL__66 GDL_67 PG0_67 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC68 BL_68 BL__67 GDL_68 PG0_68 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC69 BL_69 BL__68 GDL_69 PG0_69 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC70 BL_70 BL__69 GDL_70 PG0_70 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC71 BL_71 BL__70 GDL_71 PG0_71 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC72 BL_72 BL__71 GDL_72 PG0_72 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC73 BL_73 BL__72 GDL_73 PG0_73 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC74 BL_74 BL__73 GDL_74 PG0_74 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC75 BL_75 BL__74 GDL_75 PG0_75 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC76 BL_76 BL__75 GDL_76 PG0_76 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC77 BL_77 BL__76 GDL_77 PG0_77 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC78 BL_78 BL__77 GDL_78 PG0_78 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC79 BL_79 BL__78 GDL_79 PG0_79 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC80 BL_80 BL__79 GDL_80 PG0_80 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC81 BL_81 BL__80 GDL_81 PG0_81 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC82 BL_82 BL__81 GDL_82 PG0_82 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC83 BL_83 BL__82 GDL_83 PG0_83 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC84 BL_84 BL__83 GDL_84 PG0_84 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC85 BL_85 BL__84 GDL_85 PG0_85 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC86 BL_86 BL__85 GDL_86 PG0_86 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC87 BL_87 BL__86 GDL_87 PG0_87 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC88 BL_88 BL__87 GDL_88 PG0_88 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC89 BL_89 BL__88 GDL_89 PG0_89 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC90 BL_90 BL__89 GDL_90 PG0_90 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC91 BL_91 BL__90 GDL_91 PG0_91 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC92 BL_92 BL__91 GDL_92 PG0_92 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC93 BL_93 BL__92 GDL_93 PG0_93 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC94 BL_94 BL__93 GDL_94 PG0_94 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC95 BL_95 BL__94 GDL_95 PG0_95 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC96 BL_96 BL__95 GDL_96 PG0_96 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC97 BL_97 BL__96 GDL_97 PG0_97 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC98 BL_98 BL__97 GDL_98 PG0_98 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC99 BL_99 BL__98 GDL_99 PG0_99 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16CC_ROW128LE
****
.SUBCKT lut_sram_1024x16CCW BL BL_ CORED CORED_ DIFF1 DIFF2 GDL PG0 WL VSSE
+  VDDPE VDDCE
** lut_sram_1024x16CCW: 6 flat devices **
M0 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M3 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M4 DIFF1 WL CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL DIFF2 VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS lut_sram_1024x16CCW
****
.SUBCKT lut_sram_1024x16MWL_CC BL BL_ DIFF1 DIFF2 GDL PG0 WL VSSE VDDPE VDDCE
** lut_sram_1024x16MWL_CC: 6 flat devices **
XI0 BL BL_ CORED CORED_ DIFF1 DIFF2 GDL PG0 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCW
.ENDS lut_sram_1024x16MWL_CC
****
.SUBCKT lut_sram_1024x16FLMW BL BL_ DIFF1 DIFF2 GDL PG0 WL0 WL1 VSSE VDDPE
+  VDDCE
** lut_sram_1024x16FLMW: 6 flat devices **
M0 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M1 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M2 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M3 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M4 DIFF1 WL0 CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N2/N00
M5 CORED_ WL1 DIFF2 VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS lut_sram_1024x16FLMW
****
.SUBCKT lut_sram_1024x16MWL_ROW128LO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3
+  DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12
+  DIFF1_13 DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20
+  DIFF1_21 DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28
+  DIFF1_29 DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36
+  DIFF1_37 DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44
+  DIFF1_45 DIFF1_46 DIFF1_47 DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52
+  DIFF1_53 DIFF1_54 DIFF1_55 DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60
+  DIFF1_61 DIFF1_62 DIFF1_63 DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68
+  DIFF1_69 DIFF1_70 DIFF1_71 DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76
+  DIFF1_77 DIFF1_78 DIFF1_79 DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84
+  DIFF1_85 DIFF1_86 DIFF1_87 DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92
+  DIFF1_93 DIFF1_94 DIFF1_95 DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100
+  DIFF1_101 DIFF1_102 DIFF1_103 DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107
+  DIFF1_108 DIFF1_109 DIFF1_110 DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114
+  DIFF1_115 DIFF1_116 DIFF1_117 DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121
+  DIFF1_122 DIFF1_123 DIFF1_124 DIFF1_125 DIFF1_126 DIFF1_127 DIFF2_0 DIFF2_1
+  DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10
+  DIFF2_11 DIFF2_12 DIFF2_13 DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18
+  DIFF2_19 DIFF2_20 DIFF2_21 DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26
+  DIFF2_27 DIFF2_28 DIFF2_29 DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34
+  DIFF2_35 DIFF2_36 DIFF2_37 DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42
+  DIFF2_43 DIFF2_44 DIFF2_45 DIFF2_46 DIFF2_47 DIFF2_48 DIFF2_49 DIFF2_50
+  DIFF2_51 DIFF2_52 DIFF2_53 DIFF2_54 DIFF2_55 DIFF2_56 DIFF2_57 DIFF2_58
+  DIFF2_59 DIFF2_60 DIFF2_61 DIFF2_62 DIFF2_63 DIFF2_64 DIFF2_65 DIFF2_66
+  DIFF2_67 DIFF2_68 DIFF2_69 DIFF2_70 DIFF2_71 DIFF2_72 DIFF2_73 DIFF2_74
+  DIFF2_75 DIFF2_76 DIFF2_77 DIFF2_78 DIFF2_79 DIFF2_80 DIFF2_81 DIFF2_82
+  DIFF2_83 DIFF2_84 DIFF2_85 DIFF2_86 DIFF2_87 DIFF2_88 DIFF2_89 DIFF2_90
+  DIFF2_91 DIFF2_92 DIFF2_93 DIFF2_94 DIFF2_95 DIFF2_96 DIFF2_97 DIFF2_98
+  DIFF2_99 DIFF2_100 DIFF2_101 DIFF2_102 DIFF2_103 DIFF2_104 DIFF2_105
+  DIFF2_106 DIFF2_107 DIFF2_108 DIFF2_109 DIFF2_110 DIFF2_111 DIFF2_112
+  DIFF2_113 DIFF2_114 DIFF2_115 DIFF2_116 DIFF2_117 DIFF2_118 DIFF2_119
+  DIFF2_120 DIFF2_121 DIFF2_122 DIFF2_123 DIFF2_124 DIFF2_125 DIFF2_126
+  DIFF2_127 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89
+  GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99
+  GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108
+  GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117
+  GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126
+  GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL1 VSSE VDDPE VDDCE
** lut_sram_1024x16MWL_ROW128LO: 774 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 DIFF2_0 GDL_1 PG0_1 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC10 BL_10 BL__9 DIFF1_9 DIFF2_9 GDL_10 PG0_10 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC100 BL_100 BL__99 DIFF1_99 DIFF2_99 GDL_100 PG0_100 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC101 BL_101 BL__100 DIFF1_100 DIFF2_100 GDL_101 PG0_101 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC102 BL_102 BL__101 DIFF1_101 DIFF2_101 GDL_102 PG0_102 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC103 BL_103 BL__102 DIFF1_102 DIFF2_102 GDL_103 PG0_103 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC104 BL_104 BL__103 DIFF1_103 DIFF2_103 GDL_104 PG0_104 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC105 BL_105 BL__104 DIFF1_104 DIFF2_104 GDL_105 PG0_105 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC106 BL_106 BL__105 DIFF1_105 DIFF2_105 GDL_106 PG0_106 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC107 BL_107 BL__106 DIFF1_106 DIFF2_106 GDL_107 PG0_107 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC108 BL_108 BL__107 DIFF1_107 DIFF2_107 GDL_108 PG0_108 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC109 BL_109 BL__108 DIFF1_108 DIFF2_108 GDL_109 PG0_109 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC11 BL_11 BL__10 DIFF1_10 DIFF2_10 GDL_11 PG0_11 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC110 BL_110 BL__109 DIFF1_109 DIFF2_109 GDL_110 PG0_110 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC111 BL_111 BL__110 DIFF1_110 DIFF2_110 GDL_111 PG0_111 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC112 BL_112 BL__111 DIFF1_111 DIFF2_111 GDL_112 PG0_112 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC113 BL_113 BL__112 DIFF1_112 DIFF2_112 GDL_113 PG0_113 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC114 BL_114 BL__113 DIFF1_113 DIFF2_113 GDL_114 PG0_114 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC115 BL_115 BL__114 DIFF1_114 DIFF2_114 GDL_115 PG0_115 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC116 BL_116 BL__115 DIFF1_115 DIFF2_115 GDL_116 PG0_116 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC117 BL_117 BL__116 DIFF1_116 DIFF2_116 GDL_117 PG0_117 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC118 BL_118 BL__117 DIFF1_117 DIFF2_117 GDL_118 PG0_118 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC119 BL_119 BL__118 DIFF1_118 DIFF2_118 GDL_119 PG0_119 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC12 BL_12 BL__11 DIFF1_11 DIFF2_11 GDL_12 PG0_12 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC120 BL_120 BL__119 DIFF1_119 DIFF2_119 GDL_120 PG0_120 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC121 BL_121 BL__120 DIFF1_120 DIFF2_120 GDL_121 PG0_121 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC122 BL_122 BL__121 DIFF1_121 DIFF2_121 GDL_122 PG0_122 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC123 BL_123 BL__122 DIFF1_122 DIFF2_122 GDL_123 PG0_123 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC124 BL_124 BL__123 DIFF1_123 DIFF2_123 GDL_124 PG0_124 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC125 BL_125 BL__124 DIFF1_124 DIFF2_124 GDL_125 PG0_125 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC126 BL_126 BL__125 DIFF1_125 DIFF2_125 GDL_126 PG0_126 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC127 BL_127 BL__126 DIFF1_126 DIFF2_126 GDL_127 PG0_127 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC128 BL_128 BL__127 DIFF1_127 DIFF2_127 GDL_128 PG0_128 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC13 BL_13 BL__12 DIFF1_12 DIFF2_12 GDL_13 PG0_13 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC14 BL_14 BL__13 DIFF1_13 DIFF2_13 GDL_14 PG0_14 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC15 BL_15 BL__14 DIFF1_14 DIFF2_14 GDL_15 PG0_15 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC16 BL_16 BL__15 DIFF1_15 DIFF2_15 GDL_16 PG0_16 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC17 BL_17 BL__16 DIFF1_16 DIFF2_16 GDL_17 PG0_17 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC18 BL_18 BL__17 DIFF1_17 DIFF2_17 GDL_18 PG0_18 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC19 BL_19 BL__18 DIFF1_18 DIFF2_18 GDL_19 PG0_19 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC2 BL_2 BL__1 DIFF1_1 DIFF2_1 GDL_2 PG0_2 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC20 BL_20 BL__19 DIFF1_19 DIFF2_19 GDL_20 PG0_20 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC21 BL_21 BL__20 DIFF1_20 DIFF2_20 GDL_21 PG0_21 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC22 BL_22 BL__21 DIFF1_21 DIFF2_21 GDL_22 PG0_22 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC23 BL_23 BL__22 DIFF1_22 DIFF2_22 GDL_23 PG0_23 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC24 BL_24 BL__23 DIFF1_23 DIFF2_23 GDL_24 PG0_24 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC25 BL_25 BL__24 DIFF1_24 DIFF2_24 GDL_25 PG0_25 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC26 BL_26 BL__25 DIFF1_25 DIFF2_25 GDL_26 PG0_26 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC27 BL_27 BL__26 DIFF1_26 DIFF2_26 GDL_27 PG0_27 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC28 BL_28 BL__27 DIFF1_27 DIFF2_27 GDL_28 PG0_28 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC29 BL_29 BL__28 DIFF1_28 DIFF2_28 GDL_29 PG0_29 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC3 BL_3 BL__2 DIFF1_2 DIFF2_2 GDL_3 PG0_3 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC30 BL_30 BL__29 DIFF1_29 DIFF2_29 GDL_30 PG0_30 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC31 BL_31 BL__30 DIFF1_30 DIFF2_30 GDL_31 PG0_31 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC32 BL_32 BL__31 DIFF1_31 DIFF2_31 GDL_32 PG0_32 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC33 BL_33 BL__32 DIFF1_32 DIFF2_32 GDL_33 PG0_33 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC34 BL_34 BL__33 DIFF1_33 DIFF2_33 GDL_34 PG0_34 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC35 BL_35 BL__34 DIFF1_34 DIFF2_34 GDL_35 PG0_35 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC36 BL_36 BL__35 DIFF1_35 DIFF2_35 GDL_36 PG0_36 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC37 BL_37 BL__36 DIFF1_36 DIFF2_36 GDL_37 PG0_37 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC38 BL_38 BL__37 DIFF1_37 DIFF2_37 GDL_38 PG0_38 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC39 BL_39 BL__38 DIFF1_38 DIFF2_38 GDL_39 PG0_39 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC4 BL_4 BL__3 DIFF1_3 DIFF2_3 GDL_4 PG0_4 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC40 BL_40 BL__39 DIFF1_39 DIFF2_39 GDL_40 PG0_40 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC41 BL_41 BL__40 DIFF1_40 DIFF2_40 GDL_41 PG0_41 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC42 BL_42 BL__41 DIFF1_41 DIFF2_41 GDL_42 PG0_42 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC43 BL_43 BL__42 DIFF1_42 DIFF2_42 GDL_43 PG0_43 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC44 BL_44 BL__43 DIFF1_43 DIFF2_43 GDL_44 PG0_44 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC45 BL_45 BL__44 DIFF1_44 DIFF2_44 GDL_45 PG0_45 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC46 BL_46 BL__45 DIFF1_45 DIFF2_45 GDL_46 PG0_46 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC47 BL_47 BL__46 DIFF1_46 DIFF2_46 GDL_47 PG0_47 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC48 BL_48 BL__47 DIFF1_47 DIFF2_47 GDL_48 PG0_48 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC49 BL_49 BL__48 DIFF1_48 DIFF2_48 GDL_49 PG0_49 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC5 BL_5 BL__4 DIFF1_4 DIFF2_4 GDL_5 PG0_5 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC50 BL_50 BL__49 DIFF1_49 DIFF2_49 GDL_50 PG0_50 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC51 BL_51 BL__50 DIFF1_50 DIFF2_50 GDL_51 PG0_51 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC52 BL_52 BL__51 DIFF1_51 DIFF2_51 GDL_52 PG0_52 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC53 BL_53 BL__52 DIFF1_52 DIFF2_52 GDL_53 PG0_53 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC54 BL_54 BL__53 DIFF1_53 DIFF2_53 GDL_54 PG0_54 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC55 BL_55 BL__54 DIFF1_54 DIFF2_54 GDL_55 PG0_55 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC56 BL_56 BL__55 DIFF1_55 DIFF2_55 GDL_56 PG0_56 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC57 BL_57 BL__56 DIFF1_56 DIFF2_56 GDL_57 PG0_57 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC58 BL_58 BL__57 DIFF1_57 DIFF2_57 GDL_58 PG0_58 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC59 BL_59 BL__58 DIFF1_58 DIFF2_58 GDL_59 PG0_59 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC6 BL_6 BL__5 DIFF1_5 DIFF2_5 GDL_6 PG0_6 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC60 BL_60 BL__59 DIFF1_59 DIFF2_59 GDL_60 PG0_60 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC61 BL_61 BL__60 DIFF1_60 DIFF2_60 GDL_61 PG0_61 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC62 BL_62 BL__61 DIFF1_61 DIFF2_61 GDL_62 PG0_62 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC63 BL_63 BL__62 DIFF1_62 DIFF2_62 GDL_63 PG0_63 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC64 BL_64 BL__63 DIFF1_63 DIFF2_63 GDL_64 PG0_64 TL0_1 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16FLMW
XCC65 BL_65 BL__64 DIFF1_64 DIFF2_64 GDL_65 PG0_65 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC66 BL_66 BL__65 DIFF1_65 DIFF2_65 GDL_66 PG0_66 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC67 BL_67 BL__66 DIFF1_66 DIFF2_66 GDL_67 PG0_67 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC68 BL_68 BL__67 DIFF1_67 DIFF2_67 GDL_68 PG0_68 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC69 BL_69 BL__68 DIFF1_68 DIFF2_68 GDL_69 PG0_69 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC7 BL_7 BL__6 DIFF1_6 DIFF2_6 GDL_7 PG0_7 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC70 BL_70 BL__69 DIFF1_69 DIFF2_69 GDL_70 PG0_70 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC71 BL_71 BL__70 DIFF1_70 DIFF2_70 GDL_71 PG0_71 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC72 BL_72 BL__71 DIFF1_71 DIFF2_71 GDL_72 PG0_72 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC73 BL_73 BL__72 DIFF1_72 DIFF2_72 GDL_73 PG0_73 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC74 BL_74 BL__73 DIFF1_73 DIFF2_73 GDL_74 PG0_74 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC75 BL_75 BL__74 DIFF1_74 DIFF2_74 GDL_75 PG0_75 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC76 BL_76 BL__75 DIFF1_75 DIFF2_75 GDL_76 PG0_76 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC77 BL_77 BL__76 DIFF1_76 DIFF2_76 GDL_77 PG0_77 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC78 BL_78 BL__77 DIFF1_77 DIFF2_77 GDL_78 PG0_78 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC79 BL_79 BL__78 DIFF1_78 DIFF2_78 GDL_79 PG0_79 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC8 BL_8 BL__7 DIFF1_7 DIFF2_7 GDL_8 PG0_8 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC80 BL_80 BL__79 DIFF1_79 DIFF2_79 GDL_80 PG0_80 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC81 BL_81 BL__80 DIFF1_80 DIFF2_80 GDL_81 PG0_81 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC82 BL_82 BL__81 DIFF1_81 DIFF2_81 GDL_82 PG0_82 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC83 BL_83 BL__82 DIFF1_82 DIFF2_82 GDL_83 PG0_83 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC84 BL_84 BL__83 DIFF1_83 DIFF2_83 GDL_84 PG0_84 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC85 BL_85 BL__84 DIFF1_84 DIFF2_84 GDL_85 PG0_85 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC86 BL_86 BL__85 DIFF1_85 DIFF2_85 GDL_86 PG0_86 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC87 BL_87 BL__86 DIFF1_86 DIFF2_86 GDL_87 PG0_87 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC88 BL_88 BL__87 DIFF1_87 DIFF2_87 GDL_88 PG0_88 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC89 BL_89 BL__88 DIFF1_88 DIFF2_88 GDL_89 PG0_89 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC9 BL_9 BL__8 DIFF1_8 DIFF2_8 GDL_9 PG0_9 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC90 BL_90 BL__89 DIFF1_89 DIFF2_89 GDL_90 PG0_90 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC91 BL_91 BL__90 DIFF1_90 DIFF2_90 GDL_91 PG0_91 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC92 BL_92 BL__91 DIFF1_91 DIFF2_91 GDL_92 PG0_92 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC93 BL_93 BL__92 DIFF1_92 DIFF2_92 GDL_93 PG0_93 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC94 BL_94 BL__93 DIFF1_93 DIFF2_93 GDL_94 PG0_94 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC95 BL_95 BL__94 DIFF1_94 DIFF2_94 GDL_95 PG0_95 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC96 BL_96 BL__95 DIFF1_95 DIFF2_95 GDL_96 PG0_96 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC97 BL_97 BL__96 DIFF1_96 DIFF2_96 GDL_97 PG0_97 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC98 BL_98 BL__97 DIFF1_97 DIFF2_97 GDL_98 PG0_98 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC99 BL_99 BL__98 DIFF1_98 DIFF2_98 GDL_99 PG0_99 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16MWL_ROW128LO
****
.SUBCKT lut_sram_1024x16CCCAPBK BL BL_ DIFF1 GDL PG0 WL VSSE VDDPE VDDCE
** lut_sram_1024x16CCCAPBK: 6 flat devices **
M0 CORED CORED_ VDDCE VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P1/P00
M1 VDDCE CORED CORED_ VDDCE PCHPU_SR W=0.08U L=0.065U M=1 $name=/P0/P00
M2 VSSE CORED_ CORED VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N1/N00
M3 CORED_ CORED VSSE VSSE NCHPD_SR W=0.14U L=0.065U M=1 $name=/N0/N00
M4 DIFF1 WL CORED VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N4/N00
M5 CORED_ WL BL_ VSSE NCHPG_SR W=0.09U L=0.075U M=1 $name=/N3/N00
.ENDS lut_sram_1024x16CCCAPBK
****
.SUBCKT lut_sram_1024x16CAPBK_ROW128LE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3
+  DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12
+  DIFF1_13 DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20
+  DIFF1_21 DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28
+  DIFF1_29 DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36
+  DIFF1_37 DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44
+  DIFF1_45 DIFF1_46 DIFF1_47 DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52
+  DIFF1_53 DIFF1_54 DIFF1_55 DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60
+  DIFF1_61 DIFF1_62 DIFF1_63 DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68
+  DIFF1_69 DIFF1_70 DIFF1_71 DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76
+  DIFF1_77 DIFF1_78 DIFF1_79 DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84
+  DIFF1_85 DIFF1_86 DIFF1_87 DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92
+  DIFF1_93 DIFF1_94 DIFF1_95 DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100
+  DIFF1_101 DIFF1_102 DIFF1_103 DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107
+  DIFF1_108 DIFF1_109 DIFF1_110 DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114
+  DIFF1_115 DIFF1_116 DIFF1_117 DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121
+  DIFF1_122 DIFF1_123 DIFF1_124 DIFF1_125 DIFF1_126 DIFF1_127 GDL_0 GDL_1
+  GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53
+  GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63
+  GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73
+  GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83
+  GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93
+  GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103
+  GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112
+  GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121
+  GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0
+  PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12
+  PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22
+  PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32
+  PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92
+  PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102
+  PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111
+  PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120
+  PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1
+  TL1 WL VSSE VDDPE VDDCE
** lut_sram_1024x16CAPBK_ROW128LE: 774 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC10 BL_10 BL__9 DIFF1_9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC100 BL_100 BL__99 DIFF1_99 GDL_100 PG0_100 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC101 BL_101 BL__100 DIFF1_100 GDL_101 PG0_101 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC102 BL_102 BL__101 DIFF1_101 GDL_102 PG0_102 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC103 BL_103 BL__102 DIFF1_102 GDL_103 PG0_103 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC104 BL_104 BL__103 DIFF1_103 GDL_104 PG0_104 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC105 BL_105 BL__104 DIFF1_104 GDL_105 PG0_105 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC106 BL_106 BL__105 DIFF1_105 GDL_106 PG0_106 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC107 BL_107 BL__106 DIFF1_106 GDL_107 PG0_107 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC108 BL_108 BL__107 DIFF1_107 GDL_108 PG0_108 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC109 BL_109 BL__108 DIFF1_108 GDL_109 PG0_109 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC11 BL_11 BL__10 DIFF1_10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC110 BL_110 BL__109 DIFF1_109 GDL_110 PG0_110 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC111 BL_111 BL__110 DIFF1_110 GDL_111 PG0_111 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC112 BL_112 BL__111 DIFF1_111 GDL_112 PG0_112 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC113 BL_113 BL__112 DIFF1_112 GDL_113 PG0_113 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC114 BL_114 BL__113 DIFF1_113 GDL_114 PG0_114 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC115 BL_115 BL__114 DIFF1_114 GDL_115 PG0_115 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC116 BL_116 BL__115 DIFF1_115 GDL_116 PG0_116 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC117 BL_117 BL__116 DIFF1_116 GDL_117 PG0_117 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC118 BL_118 BL__117 DIFF1_117 GDL_118 PG0_118 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC119 BL_119 BL__118 DIFF1_118 GDL_119 PG0_119 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC12 BL_12 BL__11 DIFF1_11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC120 BL_120 BL__119 DIFF1_119 GDL_120 PG0_120 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC121 BL_121 BL__120 DIFF1_120 GDL_121 PG0_121 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC122 BL_122 BL__121 DIFF1_121 GDL_122 PG0_122 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC123 BL_123 BL__122 DIFF1_122 GDL_123 PG0_123 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC124 BL_124 BL__123 DIFF1_123 GDL_124 PG0_124 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC125 BL_125 BL__124 DIFF1_124 GDL_125 PG0_125 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC126 BL_126 BL__125 DIFF1_125 GDL_126 PG0_126 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC127 BL_127 BL__126 DIFF1_126 GDL_127 PG0_127 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC128 BL_128 BL__127 DIFF1_127 GDL_128 PG0_128 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC13 BL_13 BL__12 DIFF1_12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC14 BL_14 BL__13 DIFF1_13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC15 BL_15 BL__14 DIFF1_14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC16 BL_16 BL__15 DIFF1_15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC17 BL_17 BL__16 DIFF1_16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC18 BL_18 BL__17 DIFF1_17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC19 BL_19 BL__18 DIFF1_18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC2 BL_2 BL__1 DIFF1_1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC20 BL_20 BL__19 DIFF1_19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC21 BL_21 BL__20 DIFF1_20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC22 BL_22 BL__21 DIFF1_21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC23 BL_23 BL__22 DIFF1_22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC24 BL_24 BL__23 DIFF1_23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC25 BL_25 BL__24 DIFF1_24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC26 BL_26 BL__25 DIFF1_25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC27 BL_27 BL__26 DIFF1_26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC28 BL_28 BL__27 DIFF1_27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC29 BL_29 BL__28 DIFF1_28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC3 BL_3 BL__2 DIFF1_2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC30 BL_30 BL__29 DIFF1_29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC31 BL_31 BL__30 DIFF1_30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC32 BL_32 BL__31 DIFF1_31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC33 BL_33 BL__32 DIFF1_32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC34 BL_34 BL__33 DIFF1_33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC35 BL_35 BL__34 DIFF1_34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC36 BL_36 BL__35 DIFF1_35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC37 BL_37 BL__36 DIFF1_36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC38 BL_38 BL__37 DIFF1_37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC39 BL_39 BL__38 DIFF1_38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC4 BL_4 BL__3 DIFF1_3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC40 BL_40 BL__39 DIFF1_39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC41 BL_41 BL__40 DIFF1_40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC42 BL_42 BL__41 DIFF1_41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC43 BL_43 BL__42 DIFF1_42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC44 BL_44 BL__43 DIFF1_43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC45 BL_45 BL__44 DIFF1_44 GDL_45 PG0_45 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC46 BL_46 BL__45 DIFF1_45 GDL_46 PG0_46 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC47 BL_47 BL__46 DIFF1_46 GDL_47 PG0_47 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC48 BL_48 BL__47 DIFF1_47 GDL_48 PG0_48 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC49 BL_49 BL__48 DIFF1_48 GDL_49 PG0_49 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC5 BL_5 BL__4 DIFF1_4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC50 BL_50 BL__49 DIFF1_49 GDL_50 PG0_50 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC51 BL_51 BL__50 DIFF1_50 GDL_51 PG0_51 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC52 BL_52 BL__51 DIFF1_51 GDL_52 PG0_52 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC53 BL_53 BL__52 DIFF1_52 GDL_53 PG0_53 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC54 BL_54 BL__53 DIFF1_53 GDL_54 PG0_54 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC55 BL_55 BL__54 DIFF1_54 GDL_55 PG0_55 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC56 BL_56 BL__55 DIFF1_55 GDL_56 PG0_56 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC57 BL_57 BL__56 DIFF1_56 GDL_57 PG0_57 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC58 BL_58 BL__57 DIFF1_57 GDL_58 PG0_58 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC59 BL_59 BL__58 DIFF1_58 GDL_59 PG0_59 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC6 BL_6 BL__5 DIFF1_5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC60 BL_60 BL__59 DIFF1_59 GDL_60 PG0_60 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC61 BL_61 BL__60 DIFF1_60 GDL_61 PG0_61 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC62 BL_62 BL__61 DIFF1_61 GDL_62 PG0_62 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC63 BL_63 BL__62 DIFF1_62 GDL_63 PG0_63 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC64 BL_64 BL__63 DIFF1_63 GDL_64 PG0_64 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC65 BL_65 BL__64 DIFF1_64 GDL_65 PG0_65 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC66 BL_66 BL__65 DIFF1_65 GDL_66 PG0_66 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC67 BL_67 BL__66 DIFF1_66 GDL_67 PG0_67 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC68 BL_68 BL__67 DIFF1_67 GDL_68 PG0_68 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC69 BL_69 BL__68 DIFF1_68 GDL_69 PG0_69 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC7 BL_7 BL__6 DIFF1_6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC70 BL_70 BL__69 DIFF1_69 GDL_70 PG0_70 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC71 BL_71 BL__70 DIFF1_70 GDL_71 PG0_71 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC72 BL_72 BL__71 DIFF1_71 GDL_72 PG0_72 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC73 BL_73 BL__72 DIFF1_72 GDL_73 PG0_73 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC74 BL_74 BL__73 DIFF1_73 GDL_74 PG0_74 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC75 BL_75 BL__74 DIFF1_74 GDL_75 PG0_75 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC76 BL_76 BL__75 DIFF1_75 GDL_76 PG0_76 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC77 BL_77 BL__76 DIFF1_76 GDL_77 PG0_77 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC78 BL_78 BL__77 DIFF1_77 GDL_78 PG0_78 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC79 BL_79 BL__78 DIFF1_78 GDL_79 PG0_79 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC8 BL_8 BL__7 DIFF1_7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC80 BL_80 BL__79 DIFF1_79 GDL_80 PG0_80 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC81 BL_81 BL__80 DIFF1_80 GDL_81 PG0_81 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC82 BL_82 BL__81 DIFF1_81 GDL_82 PG0_82 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC83 BL_83 BL__82 DIFF1_82 GDL_83 PG0_83 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC84 BL_84 BL__83 DIFF1_83 GDL_84 PG0_84 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC85 BL_85 BL__84 DIFF1_84 GDL_85 PG0_85 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC86 BL_86 BL__85 DIFF1_85 GDL_86 PG0_86 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC87 BL_87 BL__86 DIFF1_86 GDL_87 PG0_87 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC88 BL_88 BL__87 DIFF1_87 GDL_88 PG0_88 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC89 BL_89 BL__88 DIFF1_88 GDL_89 PG0_89 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC9 BL_9 BL__8 DIFF1_8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC90 BL_90 BL__89 DIFF1_89 GDL_90 PG0_90 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC91 BL_91 BL__90 DIFF1_90 GDL_91 PG0_91 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC92 BL_92 BL__91 DIFF1_91 GDL_92 PG0_92 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC93 BL_93 BL__92 DIFF1_92 GDL_93 PG0_93 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC94 BL_94 BL__93 DIFF1_93 GDL_94 PG0_94 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC95 BL_95 BL__94 DIFF1_94 GDL_95 PG0_95 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC96 BL_96 BL__95 DIFF1_95 GDL_96 PG0_96 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC97 BL_97 BL__96 DIFF1_96 GDL_97 PG0_97 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC98 BL_98 BL__97 DIFF1_97 GDL_98 PG0_98 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC99 BL_99 BL__98 DIFF1_98 GDL_99 PG0_99 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16CAPBK_ROW128LE
****
.SUBCKT lut_sram_1024x16CABL128X64TT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6
+  GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17
+  GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27
+  GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37
+  GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47
+  GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57
+  GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67
+  GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77
+  GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87
+  GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97
+  GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106
+  GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115
+  GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124
+  GDL_125 GDL_126 GDL_127 GDL_128 MBL PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46
+  PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56
+  PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66
+  PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76
+  PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86
+  PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96
+  PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105
+  PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114
+  PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123
+  PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 VSSE VDDPE VDDCE
** lut_sram_1024x16CABL128X64TT: 51858 flat devices **
XCC_ROW0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_683 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_685 PDIFF_687 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_0 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_683 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_685 PDIFF_689 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_595 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_597 PDIFF_599 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_10 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_595 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_597 PDIFF_601 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_11 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_607 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_609 PDIFF_601 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_12 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_607 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_609 PDIFF_613 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_13 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_623 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_625 PDIFF_613 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_14 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_623 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_625 PDIFF_631 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_15 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_641 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_643 PDIFF_631 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_16 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW17 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_641 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_643 PDIFF_649 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_17 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_659 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_661 PDIFF_649 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_18 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_659 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_661 PDIFF_667 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_19 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_691 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_693 PDIFF_689 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_2 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF PDIFF_667 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_20 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW21 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49
+  PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59
+  PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69
+  PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79
+  PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89
+  PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99
+  PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108
+  PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117
+  PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126
+  PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_21 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_11 PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_22 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_11 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_23 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_29 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_24 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW25 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_29 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_25 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_47 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_26 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_47 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_27 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_61 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_28 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW29 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_61 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_29 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_691 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_693 PDIFF_695 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_3 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_603 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_605 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_30 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_603 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_605 PDIFF_611 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_31 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_615 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_617 PDIFF_611 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_32 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW33 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_615 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_617 PDIFF_627 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_33 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_633 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_635 PDIFF_627 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_34 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_633 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_635 PDIFF_645 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_35 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_651 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_653 PDIFF_645 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_36 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW37 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_651 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_653 PDIFF_663 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_37 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW38 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_669 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_671 PDIFF_663 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_38 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW39 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_669 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_671 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_39 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_697 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_699 PDIFF_695 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_4 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_5 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_40 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW41 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_5 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_41 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW42 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_19 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_42 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW43 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_19 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_43 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_39 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_44 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW45 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_39 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_45 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW46 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_57 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_46 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW47 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_57 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_47 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
