+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_69 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_48 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW49 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_69 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_49 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW5 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_697 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_699 PDIFF_701 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_5 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW50 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_619 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_621 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_50 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW51 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_619 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_621 PDIFF_629 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_51 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_637 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_639 PDIFF_629 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_52 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW53 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_637 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_639 PDIFF_647 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_53 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW54 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_655 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_657 PDIFF_647 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_54 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW55 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_655 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_657 PDIFF_665 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_55 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_673 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_675 PDIFF_665 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_56 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW57 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_673 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_675 PDIFF_677 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_57 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW58 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_679 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_681 PDIFF_677 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_58 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW59 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_679 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_681 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_59 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW6 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_703 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_705 PDIFF_701 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_6 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW60 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_23 PDIFF_25 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_60 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW61 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_21 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_23 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_61 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW62 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_43 PDIFF_33 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_62 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW63 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_41 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_43 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_63 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW7 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_703 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_705 PDIFF_707 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_7 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XCC_ROW8 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_709 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_711 PDIFF_707 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_8 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LE
XCC_ROW9 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_709 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_711 PDIFF_599 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_9 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128LO
XI66 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13
+  BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25
+  BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37
+  BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49
+  BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61
+  BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73
+  BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85
+  BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97
+  BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108
+  BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127 BL_128 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12
+  BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22
+  BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42
+  BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50 BL__51 BL__52
+  BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60 BL__61 BL__62
+  BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL__71 BL__72
+  BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80 BL__81 BL__82
+  BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92
+  BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100 BL__101 BL__102
+  BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109 BL__110 BL__111
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BL__119 BL__120
+  BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL DIFF_591
+  DIFF1_0_589 DIFF1_1_587 DIFF1_2_585 DIFF1_3_583 DIFF1_4_581 DIFF1_5_579
+  DIFF1_6_577 DIFF1_7_575 DIFF1_8_573 DIFF1_9_571 DIFF1_10_569 DIFF1_11_567
+  DIFF1_12_565 DIFF1_13_563 DIFF1_14_561 DIFF1_15_559 DIFF1_16_557
+  DIFF1_17_555 DIFF1_18_553 DIFF1_19_551 DIFF1_20_549 DIFF1_21_547
+  DIFF1_22_545 DIFF1_23_543 DIFF1_24_541 DIFF1_25_539 DIFF1_26_537
+  DIFF1_27_535 DIFF1_28_533 DIFF1_29_531 DIFF1_30_529 DIFF1_31_527
+  DIFF1_32_525 DIFF1_33_523 DIFF1_34_521 DIFF1_35_519 DIFF1_36_517
+  DIFF1_37_515 DIFF1_38_513 DIFF1_39_511 DIFF1_40_509 DIFF1_41_507
+  DIFF1_42_505 DIFF1_43_503 DIFF1_44_501 DIFF1_45_499 DIFF1_46_497
+  DIFF1_47_495 DIFF1_48_493 DIFF1_49_491 DIFF1_50_489 DIFF1_51_487
+  DIFF1_52_485 DIFF1_53_483 DIFF1_54_481 DIFF1_55_479 DIFF1_56_477
+  DIFF1_57_475 DIFF1_58_473 DIFF1_59_471 DIFF1_60_469 DIFF1_61_467
+  DIFF1_62_465 DIFF1_63_463 DIFF1_64_461 DIFF1_65_459 DIFF1_66_457
+  DIFF1_67_455 DIFF1_68_453 DIFF1_69_451 DIFF1_70_449 DIFF1_71_447
+  DIFF1_72_445 DIFF1_73_443 DIFF1_74_441 DIFF1_75_439 DIFF1_76_437
+  DIFF1_77_435 DIFF1_78_433 DIFF1_79_431 DIFF1_80_429 DIFF1_81_427
+  DIFF1_82_425 DIFF1_83_423 DIFF1_84_421 DIFF1_85_419 DIFF1_86_417
+  DIFF1_87_415 DIFF1_88_413 DIFF1_89_411 DIFF1_90_409 DIFF1_91_407
+  DIFF1_92_405 DIFF1_93_403 DIFF1_94_401 DIFF1_95_399 DIFF1_96_397
+  DIFF1_97_395 DIFF1_98_393 DIFF1_99_391 DIFF1_100_389 DIFF1_101_387
+  DIFF1_102_385 DIFF1_103_383 DIFF1_104_381 DIFF1_105_379 DIFF1_106_377
+  DIFF1_107_375 DIFF1_108_373 DIFF1_109_371 DIFF1_110_369 DIFF1_111_367
+  DIFF1_112_365 DIFF1_113_363 DIFF1_114_361 DIFF1_115_359 DIFF1_116_357
+  DIFF1_117_355 DIFF1_118_353 DIFF1_119_351 DIFF1_120_349 DIFF1_121_347
+  DIFF1_122_345 DIFF1_123_343 DIFF1_124_341 DIFF1_125_339 DIFF1_126_337
+  DIFF1_127_335 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89
+  GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99
+  GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108
+  GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117
+  GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126
+  GDL_127 GDL_128 NDIFF_593 PDIFF_51 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46
+  PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56
+  PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66
+  PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76
+  PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86
+  PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96
+  PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105
+  PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114
+  PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123
+  PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_64 VSSE VDDPE
+  VDDCE lut_sram_1024x16CAPBK_ROW128LE
XMWLROWBOT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_201 DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3 DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7
+  DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12 DIFF1_13 DIFF1_14 DIFF1_15
+  DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20 DIFF1_21 DIFF1_22 DIFF1_23
+  DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28 DIFF1_29 DIFF1_30 DIFF1_31
+  DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36 DIFF1_37 DIFF1_38 DIFF1_39
+  DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44 DIFF1_45 DIFF1_46 DIFF1_47
+  DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52 DIFF1_53 DIFF1_54 DIFF1_55
+  DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60 DIFF1_61 DIFF1_62 DIFF1_63
+  DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68 DIFF1_69 DIFF1_70 DIFF1_71
+  DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76 DIFF1_77 DIFF1_78 DIFF1_79
+  DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84 DIFF1_85 DIFF1_86 DIFF1_87
+  DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92 DIFF1_93 DIFF1_94 DIFF1_95
+  DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100 DIFF1_101 DIFF1_102 DIFF1_103
+  DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107 DIFF1_108 DIFF1_109 DIFF1_110
+  DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114 DIFF1_115 DIFF1_116 DIFF1_117
+  DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121 DIFF1_122 DIFF1_123 DIFF1_124
+  DIFF1_125 DIFF1_126 DIFF1_127 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4
+  DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13
+  DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21
+  DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29
+  DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37
+  DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42 DIFF2_43 DIFF2_44 DIFF2_45
+  DIFF2_46 DIFF2_47 DIFF2_48 DIFF2_49 DIFF2_50 DIFF2_51 DIFF2_52 DIFF2_53
+  DIFF2_54 DIFF2_55 DIFF2_56 DIFF2_57 DIFF2_58 DIFF2_59 DIFF2_60 DIFF2_61
+  DIFF2_62 DIFF2_63 DIFF2_64 DIFF2_65 DIFF2_66 DIFF2_67 DIFF2_68 DIFF2_69
+  DIFF2_70 DIFF2_71 DIFF2_72 DIFF2_73 DIFF2_74 DIFF2_75 DIFF2_76 DIFF2_77
+  DIFF2_78 DIFF2_79 DIFF2_80 DIFF2_81 DIFF2_82 DIFF2_83 DIFF2_84 DIFF2_85
+  DIFF2_86 DIFF2_87 DIFF2_88 DIFF2_89 DIFF2_90 DIFF2_91 DIFF2_92 DIFF2_93
+  DIFF2_94 DIFF2_95 DIFF2_96 DIFF2_97 DIFF2_98 DIFF2_99 DIFF2_100 DIFF2_101
+  DIFF2_102 DIFF2_103 DIFF2_104 DIFF2_105 DIFF2_106 DIFF2_107 DIFF2_108
+  DIFF2_109 DIFF2_110 DIFF2_111 DIFF2_112 DIFF2_113 DIFF2_114 DIFF2_115
+  DIFF2_116 DIFF2_117 DIFF2_118 DIFF2_119 DIFF2_120 DIFF2_121 DIFF2_122
+  DIFF2_123 DIFF2_124 DIFF2_125 DIFF2_126 DIFF2_127 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44
+  GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54
+  GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64
+  GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74
+  GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84
+  GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94
+  GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104
+  GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113
+  GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122
+  GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF_203 PDIFF_333 PG0_0
+  PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12
+  PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22
+  PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32
+  PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92
+  PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102
+  PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111
+  PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120
+  PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1
+  TL1 WL_65 VSSE VDDPE VDDCE lut_sram_1024x16MWL_ROW128LO
XMWLROWTOP BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_591 DIFF1_0_589 DIFF1_1_587 DIFF1_2_585 DIFF1_3_583 DIFF1_4_581
+  DIFF1_5_579 DIFF1_6_577 DIFF1_7_575 DIFF1_8_573 DIFF1_9_571 DIFF1_10_569
+  DIFF1_11_567 DIFF1_12_565 DIFF1_13_563 DIFF1_14_561 DIFF1_15_559
+  DIFF1_16_557 DIFF1_17_555 DIFF1_18_553 DIFF1_19_551 DIFF1_20_549
+  DIFF1_21_547 DIFF1_22_545 DIFF1_23_543 DIFF1_24_541 DIFF1_25_539
+  DIFF1_26_537 DIFF1_27_535 DIFF1_28_533 DIFF1_29_531 DIFF1_30_529
+  DIFF1_31_527 DIFF1_32_525 DIFF1_33_523 DIFF1_34_521 DIFF1_35_519
+  DIFF1_36_517 DIFF1_37_515 DIFF1_38_513 DIFF1_39_511 DIFF1_40_509
+  DIFF1_41_507 DIFF1_42_505 DIFF1_43_503 DIFF1_44_501 DIFF1_45_499
+  DIFF1_46_497 DIFF1_47_495 DIFF1_48_493 DIFF1_49_491 DIFF1_50_489
+  DIFF1_51_487 DIFF1_52_485 DIFF1_53_483 DIFF1_54_481 DIFF1_55_479
+  DIFF1_56_477 DIFF1_57_475 DIFF1_58_473 DIFF1_59_471 DIFF1_60_469
+  DIFF1_61_467 DIFF1_62_465 DIFF1_63_463 DIFF1_64_461 DIFF1_65_459
+  DIFF1_66_457 DIFF1_67_455 DIFF1_68_453 DIFF1_69_451 DIFF1_70_449
+  DIFF1_71_447 DIFF1_72_445 DIFF1_73_443 DIFF1_74_441 DIFF1_75_439
+  DIFF1_76_437 DIFF1_77_435 DIFF1_78_433 DIFF1_79_431 DIFF1_80_429
+  DIFF1_81_427 DIFF1_82_425 DIFF1_83_423 DIFF1_84_421 DIFF1_85_419
+  DIFF1_86_417 DIFF1_87_415 DIFF1_88_413 DIFF1_89_411 DIFF1_90_409
+  DIFF1_91_407 DIFF1_92_405 DIFF1_93_403 DIFF1_94_401 DIFF1_95_399
+  DIFF1_96_397 DIFF1_97_395 DIFF1_98_393 DIFF1_99_391 DIFF1_100_389
+  DIFF1_101_387 DIFF1_102_385 DIFF1_103_383 DIFF1_104_381 DIFF1_105_379
+  DIFF1_106_377 DIFF1_107_375 DIFF1_108_373 DIFF1_109_371 DIFF1_110_369
+  DIFF1_111_367 DIFF1_112_365 DIFF1_113_363 DIFF1_114_361 DIFF1_115_359
+  DIFF1_116_357 DIFF1_117_355 DIFF1_118_353 DIFF1_119_351 DIFF1_120_349
+  DIFF1_121_347 DIFF1_122_345 DIFF1_123_343 DIFF1_124_341 DIFF1_125_339
+  DIFF1_126_337 DIFF1_127_335 DIFF2_0 DIFF2_1 DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5
+  DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10 DIFF2_11 DIFF2_12 DIFF2_13
+  DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18 DIFF2_19 DIFF2_20 DIFF2_21
+  DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26 DIFF2_27 DIFF2_28 DIFF2_29
+  DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34 DIFF2_35 DIFF2_36 DIFF2_37
+  DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42 DIFF2_43 DIFF2_44 DIFF2_45
+  DIFF2_46 DIFF2_47 DIFF2_48 DIFF2_49 DIFF2_50 DIFF2_51 DIFF2_52 DIFF2_53
+  DIFF2_54 DIFF2_55 DIFF2_56 DIFF2_57 DIFF2_58 DIFF2_59 DIFF2_60 DIFF2_61
+  DIFF2_62 DIFF2_63 DIFF2_64 DIFF2_65 DIFF2_66 DIFF2_67 DIFF2_68 DIFF2_69
+  DIFF2_70 DIFF2_71 DIFF2_72 DIFF2_73 DIFF2_74 DIFF2_75 DIFF2_76 DIFF2_77
+  DIFF2_78 DIFF2_79 DIFF2_80 DIFF2_81 DIFF2_82 DIFF2_83 DIFF2_84 DIFF2_85
+  DIFF2_86 DIFF2_87 DIFF2_88 DIFF2_89 DIFF2_90 DIFF2_91 DIFF2_92 DIFF2_93
+  DIFF2_94 DIFF2_95 DIFF2_96 DIFF2_97 DIFF2_98 DIFF2_99 DIFF2_100 DIFF2_101
+  DIFF2_102 DIFF2_103 DIFF2_104 DIFF2_105 DIFF2_106 DIFF2_107 DIFF2_108
+  DIFF2_109 DIFF2_110 DIFF2_111 DIFF2_112 DIFF2_113 DIFF2_114 DIFF2_115
+  DIFF2_116 DIFF2_117 DIFF2_118 DIFF2_119 DIFF2_120 DIFF2_121 DIFF2_122
+  DIFF2_123 DIFF2_124 DIFF2_125 DIFF2_126 DIFF2_127 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44
+  GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54
+  GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64
+  GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74
+  GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84
+  GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94
+  GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104
+  GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113
+  GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122
+  GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF_593 PDIFF_333 PG0_0
+  PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12
+  PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22
+  PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32
+  PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92
+  PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102
+  PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111
+  PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120
+  PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1
+  TL1 WL_65 VSSE VDDPE VDDCE lut_sram_1024x16MWL_ROW128LO
.ENDS lut_sram_1024x16CABL128X64TT
****
.SUBCKT lut_sram_1024x16WD AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTPIN0
+  G0 G0X G1 G1X GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS RDTN RET RRBTP
+  RRBTPB RRBTPT RREN RXP0B RXP0T RXP1B RXP1T RXP2B RXP2T RXP3B RXP3T WL0L
+  WL0R WL1L WL1R XP0 XP1 XP2 XP3 XP4 XP4_0 XP4_1 XP5 XP6 XP7 XP8 XP9 XP10
+  XP11 VSSE VDDPE VDDCE
** lut_sram_1024x16WD: 34 flat devices **
M0 BTPIN0 WL0PD WL0I VDDCE PCH W=1.42U L=0.06U M=1 $name=/wl0ipgp/P00
M1 VDDPE XP4_0 WL0PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/tndp/P00
M10 WL1I WL1PD VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/N20/N00
M11 WL1I RET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N2/N00
M12 VDDCE WL0I WL0N VDDCE PCH_HVT W=2.16U L=0.06U M=1 $name=/wlndrp/P00
M13 VDDCE WL1I WL1N VDDCE PCH_HVT W=2.16U L=0.06U M=1 $name=/N16/P00
M14 WL0N WL0I VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/wlndrn/N00
M15 WL0I WL0PDN BTPIN0 VSSE NCH W=0.8U L=0.06U M=1 $name=/wl0ipgn/N00
M16 NET55 G1 VSSE VSSE NCH W=0.93U L=0.06U M=1 $name=/tndn/N00
M17 WL1PD XP4_1 NET65 VSSE NCH W=0.93U L=0.06U M=1 $name=/N4/N00
M18 WL1I WL1PDN BTPIN0 VSSE NCH W=0.8U L=0.06U M=1 $name=/N17/N00
M19 WL1N WL1I VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/N15/N00
M2 VDDPE XP4_1 WL1PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P4/P00
M20 NET65 G0 NET55 VSSE NCH W=0.93U L=0.06U M=1 $name=/N1/N00
M21 WL0PD XP4_0 NET65 VSSE NCH W=0.93U L=0.06U M=1 $name=/N0/N00
M22 WL1R WL1N VSSE VSSE NCH W=3.21U L=0.06U M=1 $name=/wldrv1/N00
M23 VDDCE WL1N WL1R VDDCE PCH W=11.49U L=0.06U M=1 $name=/wldrv1/P00
M24 WL0R WL0N VSSE VSSE NCH W=3.21U L=0.06U M=1 $name=/wldrv0/N00
M25 VDDCE WL0N WL0R VDDCE PCH W=11.49U L=0.06U M=1 $name=/wldrv0/P00
M26 WL0PDN WL0PD VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/gdrvb/N00
M27 VDDPE WL0PD WL0PDN VDDCE PCH W=0.28U L=0.06U M=1 $name=/gdrvb/P00
M28 WL0L WL0N VSSE VSSE NCH W=3.21U L=0.06U M=1 $name=/I60/N00
M29 VDDCE WL0N WL0L VDDCE PCH W=11.49U L=0.06U M=1 $name=/I60/P00
M3 VDDPE G0 WL1PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P3/P00
M30 WL1L WL1N VSSE VSSE NCH W=3.21U L=0.06U M=1 $name=/I59/N00
M31 VDDCE WL1N WL1L VDDCE PCH W=11.49U L=0.06U M=1 $name=/I59/P00
M32 WL1PDN WL1PD VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I15/N00
M33 VDDPE WL1PD WL1PDN VDDCE PCH W=0.28U L=0.06U M=1 $name=/I15/P00
M4 VDDPE G1 WL0PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P2/P00
M5 BTPIN0 WL1PD WL1I VDDCE PCH W=1.42U L=0.06U M=1 $name=/P13/P00
M6 VDDPE G1 WL1PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P1/P00
M7 VDDPE G0 WL0PD VDDCE PCH W=0.4U L=0.06U M=1 $name=/P0/P00
M8 WL0I WL0PD VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/kprn/N00
M9 WL0I RET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N3/N00
.ENDS lut_sram_1024x16WD
****
.SUBCKT lut_sram_1024x16MWD_1B AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AY0TRACK AY1TRACK AY2TRACK BS0N BS1N BTP0 BTP1 BTP2 BTP3 G0TERM
+  G1TERM GTP GTPD GTPDE GTPIN GTPT IRET LGWEN MBL MGDLE MGDLS MGTPE MGTPS
+  MGTPST MWL MWLLATE P1 P2 P3 P4 P5 P6 P7 P8 P9 P10 P11 P12 P13 PW1 PW2 PW3
+  RDTN RRBTP RRBTP_TERM RREN RXP0 RXP1 RXP2 RXP3 TIEHIGH TIEHIGH_TERM TIELOW
+  WBT XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
** lut_sram_1024x16MWD_1B: 65 flat devices **
D0 VSSE TIEHIGH NDIO 1.024e-07U 1.28U $name=/D5
M1 VDDCE WL1I NET424 VDDCE PCH_HVT W=2.88U L=0.06U M=1 $name=/mwlndrp/P00
M10 NET282 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N52/N00
M11 NET285 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N53/N00
M12 MBL MWLLATE NET285 VSSE NCH W=0.32U L=0.06U M=1 $name=/N54/N00
M13 MBL MWLLATE NET294 VSSE NCH W=0.32U L=0.06U M=1 $name=/N55/N00
M14 NET294 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N56/N00
M15 NET297 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N57/N00
M16 P12 MWLLATE NET297 VSSE NCH W=0.32U L=0.06U M=1 $name=/N58/N00
M17 P13 MWLLATE NET306 VSSE NCH W=0.32U L=0.06U M=1 $name=/N59/N00
M18 NET306 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N60/N00
M19 NET309 WBT VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N61/N00
M2 NET260 TIELOW VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/gdrvb/N00
M20 NET312 MWLLATE NET309 VSSE NCH W=0.32U L=0.06U M=1 $name=/N62/N00
M21 NET315 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N36/N00
M22 NET318 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N0/N00
M23 P1 MWLLATE NET345 VSSE NCH W=0.26U L=0.06U M=1 $name=/N46/N00
M24 P3 MWLLATE NET369 VSSE NCH W=0.26U L=0.06U M=1 $name=/N47/N00
M25 NET327 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N37/N00
M26 MBL MWLLATE MBL0 VSSE NCH W=0.32U L=0.06U M=1 $name=/N43/N00
M27 NET333 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N41/N00
M28 NET424 WL1I VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/mwlndrn/N00
M29 GTPIN NET260 WL1I VSSE NCH W=4.4U L=0.06U M=1 $name=/mwlipgn/N00
M3 VDDPE TIELOW NET260 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/gdrvb/P00
M30 P8 MWLLATE NET354 VSSE NCH W=0.26U L=0.06U M=1 $name=/N29/N00
M31 NET345 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N45/N00
M32 P11 MWLLATE NET366 VSSE NCH W=0.26U L=0.06U M=1 $name=/N26/N00
M33 MBL0 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N44/N00
M34 NET354 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N31/N00
M35 PW1 MWLLATE NET333 VSSE NCH W=0.32U L=0.06U M=1 $name=/N42/N00
M36 P10 MWLLATE NET363 VSSE NCH W=0.26U L=0.06U M=1 $name=/N24/N00
M37 NET363 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N19/N00
M38 NET366 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N18/N00
M39 NET369 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N48/N00
M4 WL1I TIELOW GTPIN VDDCE PCH W=4.4U L=0.06U M=1 $name=/mwlipgp/P00
M40 NET372 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N21/N00
M41 P4 MWLLATE NET381 VSSE NCH W=0.26U L=0.06U M=1 $name=/N34/N00
M42 NET378 MWLLATE NET318 VSSE NCH W=0.26U L=0.06U M=1 $name=/N27/N00
M43 NET381 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N33/N00
M44 P9 MWLLATE NET372 VSSE NCH W=0.26U L=0.06U M=1 $name=/N22/N00
M45 TIELOW TIELOW VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M46 P6 MWLLATE NET396 VSSE NCH W=0.26U L=0.06U M=1 $name=/N30/N00
M47 TIELOW TIEHIGH VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N2/N00
M48 NET396 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N32/N00
M49 P2 MWLLATE NET315 VSSE NCH W=0.26U L=0.06U M=1 $name=/N35/N00
M5 VDDPE TIEHIGH TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M50 NET402 LGWEN VSSE VSSE NCH W=0.32U L=0.06U M=1 $name=/N40/N00
M51 PW3 MWLLATE NET327 VSSE NCH W=0.32U L=0.06U M=1 $name=/N38/N00
M52 PW2 MWLLATE NET402 VSSE NCH W=0.32U L=0.06U M=1 $name=/N39/N00
M53 MWL IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N7/N00
M54 WL1I TIELOW VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/N20/N00
M55 VSSE IRET MWLL VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N17/N00
M56 WL1I IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N12/N00
M57 NET0423 GTP VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I14/N00
M58 VDDPE GTP NET0423 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I14/P00
M59 RRBTP NET0423 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I16/N00
M6 VDDPE TIELOW TIEHIGH VDDCE PCH W=0.3U L=0.06U M=1 $name=/P0/P00
M60 VDDPE NET0423 RRBTP VDDCE PCH W=2U L=0.06U M=1 $name=/I16/P00
M61 MWL NET424 VSSE VSSE NCH W=3.21U L=0.06U M=1 $name=/mwldrv/N00
M62 VDDCE NET424 MWL VDDCE PCH W=11.49U L=0.06U M=1 $name=/mwldrv/P00
M63 MWLL NET424 VSSE VSSE NCH W=6.21U L=0.06U M=1 $name=/I0/N00
M64 VDDCE NET424 MWLL VDDCE PCH W=8.49U L=0.06U M=1 $name=/I0/P00
M7 NET273 TIEHIGH VSSE VSSE NCH W=0.26U L=0.06U M=1 $name=/N49/N00
M8 P5 MWLLATE NET273 VSSE NCH W=0.26U L=0.06U M=1 $name=/N50/N00
M9 P7 MWLLATE NET282 VSSE NCH W=0.26U L=0.06U M=1 $name=/N51/N00
.ENDS lut_sram_1024x16MWD_1B
****
.SUBCKT lut_sram_1024x16WDTAP AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AX6N AY0TRACK AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 G0TERM
+  G0_TIEHIGH G1TERM G1_TIEHIGH GTP GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS
+  RDTN RET RRBTP RREN RXP0 RXP1 RXP2 RXP3 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8
+  XP9 XP10 XP11 VSSE VDDPE VDDCE
** lut_sram_1024x16WDTAP: 4 flat devices **
M0 VDDPE G1_TIEHIGH G1_TIEHIGH VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M1 VDDPE NET141 G1_TIEHIGH VDDCE PCH W=5U L=0.06U M=1 $name=/P0/P00
M2 NET141 NET141 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M3 NET141 G1_TIEHIGH VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/N2/N00
.ENDS lut_sram_1024x16WDTAP
****
.SUBCKT lut_sram_1024x16WDSEC_SB0B64 AX0TRACK AX1TRACK AX2TRACK AX3TRACK
+  AX4TRACK AX5TRACK AY0TRACK AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3
+  G0_TIEHIGH G1_TIEHIGH GTPD GTPDE GTP_0 GTP_1 LGWEN MBL MGDLE MGDLS MGTPE
+  MGTPS_0 MGTPS_1 MWL MWLLATE RDTN RET RRBTP RRBTP_TERM RREN RXP0_0 RXP0_1
+  RXP1_0 RXP1_1 RXP2_0 RXP2_1 RXP3_0 RXP3_1 TIEHIGH_TERM TIELOW WBT WL0L_0
+  WL0L_1 WL0L_2 WL0L_3 WL0L_4 WL0L_5 WL0L_6 WL0L_7 WL0L_8 WL0L_9 WL0L_10
+  WL0L_11 WL0L_12 WL0L_13 WL0L_14 WL0L_15 WL0L_16 WL0L_17 WL0L_18 WL0L_19
+  WL0L_20 WL0L_21 WL0L_22 WL0L_23 WL0L_24 WL0L_25 WL0L_26 WL0L_27 WL0L_28
+  WL0L_29 WL0L_30 WL0L_31 WL0R_0 WL0R_1 WL0R_2 WL0R_3 WL0R_4 WL0R_5 WL0R_6
+  WL0R_7 WL0R_8 WL0R_9 WL0R_10 WL0R_11 WL0R_12 WL0R_13 WL0R_14 WL0R_15
+  WL0R_16 WL0R_17 WL0R_18 WL0R_19 WL0R_20 WL0R_21 WL0R_22 WL0R_23 WL0R_24
+  WL0R_25 WL0R_26 WL0R_27 WL0R_28 WL0R_29 WL0R_30 WL0R_31 WL1L_0 WL1L_1
+  WL1L_2 WL1L_3 WL1L_4 WL1L_5 WL1L_6 WL1L_7 WL1L_8 WL1L_9 WL1L_10 WL1L_11
+  WL1L_12 WL1L_13 WL1L_14 WL1L_15 WL1L_16 WL1L_17 WL1L_18 WL1L_19 WL1L_20
+  WL1L_21 WL1L_22 WL1L_23 WL1L_24 WL1L_25 WL1L_26 WL1L_27 WL1L_28 WL1L_29
+  WL1L_30 WL1L_31 WL1R_0 WL1R_1 WL1R_2 WL1R_3 WL1R_4 WL1R_5 WL1R_6 WL1R_7
+  WL1R_8 WL1R_9 WL1R_10 WL1R_11 WL1R_12 WL1R_13 WL1R_14 WL1R_15 WL1R_16
+  WL1R_17 WL1R_18 WL1R_19 WL1R_20 WL1R_21 WL1R_22 WL1R_23 WL1R_24 WL1R_25
+  WL1R_26 WL1R_27 WL1R_28 WL1R_29 WL1R_30 WL1R_31 XP0 XP1 XP2 XP3 XP4 XP5 XP6
+  XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE
** lut_sram_1024x16WDSEC_SB0B64: 1157 flat devices **
XMWD AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 XP4 XP8 GTP_1 GTPD GTPDE MGTPS_1 GTP_0
+  RET LGWEN MBL MGDLE MGDLS MGTPE MGTPS_1 MGTPS_0 MWL MWLLATE MBL MBL MBL P4
+  P5 P6 P7 P8 P9 P10 P11 P12 P13 MBL MBL MBL RDTN RRBTP RRBTP_TERM RREN
+  RXP0_1 RXP1_1 RXP2_1 RXP3_1 TIEHIGH TIEHIGH_TERM TIELOW WBT XP0 XP1 XP2 XP3
+  XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE VDDPE VDDCE lut_sram_1024x16MWD_1B
XTOPTAP AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 XP7 G0_TIEHIGH XP9 G1_TIEHIGH
+  GTP_0 GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RREN RXP0_0
+  RXP1_0 RXP2_0 RXP3_0 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 VSSE
+  VDDPE VDDCE lut_sram_1024x16WDTAP
XWD1 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP4 XP4 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_1 RXP0_0 RXP1_1 RXP1_0 RXP2_1 RXP2_0 RXP3_1 RXP3_0 WL0L_0 WL0R_0
+  WL1L_0 WL1R_0 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD10 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP4 XP5 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_9 WL0R_9
+  WL1L_9 WL1R_9 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD11 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP5 XP5 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_10 WL0R_10
+  WL1L_10 WL1R_10 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD12 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP5 XP6 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_11 WL0R_11
+  WL1L_11 WL1R_11 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD13 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP6 XP6 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_12 WL0R_12
+  WL1L_12 WL1R_12 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD14 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP6 XP7 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_13 WL0R_13
+  WL1L_13 WL1R_13 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD15 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP7 XP7 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_14 WL0R_14
+  WL1L_14 WL1R_14 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD16 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP7 XP4 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_15 WL0R_15
+  WL1L_15 WL1R_15 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD17 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP4 XP4 XP8 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_16 WL0R_16
+  WL1L_16 WL1R_16 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD18 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP4 XP5 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_17 WL0R_17
+  WL1L_17 WL1R_17 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD19 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP5 XP5 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_18 WL0R_18
+  WL1L_18 WL1R_18 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD2 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP4 XP5 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_1 WL0R_1
+  WL1L_1 WL1R_1 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD20 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP5 XP6 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_19 WL0R_19
+  WL1L_19 WL1R_19 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD21 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP6 XP6 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_20 WL0R_20
+  WL1L_20 WL1R_20 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD22 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP6 XP7 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_21 WL0R_21
+  WL1L_21 WL1R_21 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD23 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP7 XP7 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_22 WL0R_22
+  WL1L_22 WL1R_22 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD24 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP7 XP4 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_23 WL0R_23
+  WL1L_23 WL1R_23 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD25 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP4 XP4 XP9 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_24 WL0R_24
+  WL1L_24 WL1R_24 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD26 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP4 XP5 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_25 WL0R_25
+  WL1L_25 WL1R_25 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD27 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP5 XP5 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_26 WL0R_26
+  WL1L_26 WL1R_26 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD28 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP5 XP6 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_27 WL0R_27
+  WL1L_27 WL1R_27 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD29 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP6 XP6 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_28 WL0R_28
+  WL1L_28 WL1R_28 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD3 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP5 XP5 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_2 WL0R_2
+  WL1L_2 WL1R_2 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD30 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP6 XP7 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_29 WL0R_29
+  WL1L_29 WL1R_29 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD31 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP7 XP7 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_30 WL0R_30
+  WL1L_30 WL1R_30 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD32 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP1 XP7 XP7 XP9 XP9 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_31 WL0R_31
+  WL1L_31 WL1R_31 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP5 XP6 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_3 WL0R_3
+  WL1L_3 WL1R_3 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD5 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP6 XP6 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_4 WL0R_4
+  WL1L_4 WL1R_4 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD6 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP6 XP7 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_5 WL0R_5
+  WL1L_5 WL1R_5 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD7 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP7 XP7 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_6 WL0R_6
+  WL1L_6 WL1R_6 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD8 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP7 XP4 XP8 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_7 WL0R_7
+  WL1L_7 WL1R_7 XP0 XP1 XP2 XP3 XP4 XP3 XP2 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
XWD9 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK VSSE AY0TRACK
+  AY1TRACK AY2TRACK BS0 BS1 BTP0 BTP1 BTP2 BTP3 BTP0 XP4 XP4 XP9 XP8 GTP_0
+  GTPD GTPDE LGWEN MGDLE MGDLS MGTPE MGTPS_0 RDTN RET RRBTP RRBTP RRBTP RREN
+  RXP0_0 RXP0_0 RXP1_0 RXP1_0 RXP2_0 RXP2_0 RXP3_0 RXP3_0 WL0L_8 WL0R_8
+  WL1L_8 WL1R_8 XP0 XP1 XP2 XP3 XP4 XP0 XP1 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  VSSE VDDPE VDDCE lut_sram_1024x16WD
.ENDS lut_sram_1024x16WDSEC_SB0B64
****
.SUBCKT lut_sram_1024x16CC_ROW128RO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25
+  GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55
+  GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65
+  GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75
+  GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85
+  GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95
+  GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105
+  GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114
+  GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123
+  GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3
+  PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14
+  PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24
+  PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34
+  PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44
+  PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54
+  PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64
+  PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74
+  PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84
+  PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94
+  PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104
+  PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113
+  PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122
+  PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL VSSE
+  VDDPE VDDCE
** lut_sram_1024x16CC_ROW128RO: 774 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC100 BL_100 BL__99 GDL_100 PG0_100 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC101 BL_101 BL__100 GDL_101 PG0_101 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC102 BL_102 BL__101 GDL_102 PG0_102 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC103 BL_103 BL__102 GDL_103 PG0_103 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC104 BL_104 BL__103 GDL_104 PG0_104 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC105 BL_105 BL__104 GDL_105 PG0_105 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC106 BL_106 BL__105 GDL_106 PG0_106 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC107 BL_107 BL__106 GDL_107 PG0_107 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC108 BL_108 BL__107 GDL_108 PG0_108 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC109 BL_109 BL__108 GDL_109 PG0_109 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC110 BL_110 BL__109 GDL_110 PG0_110 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC111 BL_111 BL__110 GDL_111 PG0_111 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC112 BL_112 BL__111 GDL_112 PG0_112 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC113 BL_113 BL__112 GDL_113 PG0_113 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC114 BL_114 BL__113 GDL_114 PG0_114 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC115 BL_115 BL__114 GDL_115 PG0_115 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC116 BL_116 BL__115 GDL_116 PG0_116 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC117 BL_117 BL__116 GDL_117 PG0_117 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC118 BL_118 BL__117 GDL_118 PG0_118 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC119 BL_119 BL__118 GDL_119 PG0_119 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC120 BL_120 BL__119 GDL_120 PG0_120 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC121 BL_121 BL__120 GDL_121 PG0_121 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC122 BL_122 BL__121 GDL_122 PG0_122 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC123 BL_123 BL__122 GDL_123 PG0_123 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC124 BL_124 BL__123 GDL_124 PG0_124 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC125 BL_125 BL__124 GDL_125 PG0_125 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC126 BL_126 BL__125 GDL_126 PG0_126 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC127 BL_127 BL__126 GDL_127 PG0_127 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC128 BL_128 BL__127 GDL_128 PG0_128 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC45 BL_45 BL__44 GDL_45 PG0_45 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC46 BL_46 BL__45 GDL_46 PG0_46 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC47 BL_47 BL__46 GDL_47 PG0_47 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC48 BL_48 BL__47 GDL_48 PG0_48 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC49 BL_49 BL__48 GDL_49 PG0_49 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC50 BL_50 BL__49 GDL_50 PG0_50 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC51 BL_51 BL__50 GDL_51 PG0_51 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC52 BL_52 BL__51 GDL_52 PG0_52 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC53 BL_53 BL__52 GDL_53 PG0_53 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC54 BL_54 BL__53 GDL_54 PG0_54 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC55 BL_55 BL__54 GDL_55 PG0_55 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC56 BL_56 BL__55 GDL_56 PG0_56 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC57 BL_57 BL__56 GDL_57 PG0_57 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC58 BL_58 BL__57 GDL_58 PG0_58 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC59 BL_59 BL__58 GDL_59 PG0_59 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC60 BL_60 BL__59 GDL_60 PG0_60 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC61 BL_61 BL__60 GDL_61 PG0_61 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC62 BL_62 BL__61 GDL_62 PG0_62 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC63 BL_63 BL__62 GDL_63 PG0_63 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC64 BL_64 BL__63 GDL_64 PG0_64 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC65 BL_65 BL__64 GDL_65 PG0_65 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC66 BL_66 BL__65 GDL_66 PG0_66 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC67 BL_67 BL__66 GDL_67 PG0_67 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC68 BL_68 BL__67 GDL_68 PG0_68 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC69 BL_69 BL__68 GDL_69 PG0_69 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC70 BL_70 BL__69 GDL_70 PG0_70 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC71 BL_71 BL__70 GDL_71 PG0_71 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC72 BL_72 BL__71 GDL_72 PG0_72 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC73 BL_73 BL__72 GDL_73 PG0_73 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC74 BL_74 BL__73 GDL_74 PG0_74 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC75 BL_75 BL__74 GDL_75 PG0_75 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC76 BL_76 BL__75 GDL_76 PG0_76 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC77 BL_77 BL__76 GDL_77 PG0_77 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC78 BL_78 BL__77 GDL_78 PG0_78 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC79 BL_79 BL__78 GDL_79 PG0_79 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC80 BL_80 BL__79 GDL_80 PG0_80 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC81 BL_81 BL__80 GDL_81 PG0_81 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC82 BL_82 BL__81 GDL_82 PG0_82 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC83 BL_83 BL__82 GDL_83 PG0_83 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC84 BL_84 BL__83 GDL_84 PG0_84 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC85 BL_85 BL__84 GDL_85 PG0_85 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC86 BL_86 BL__85 GDL_86 PG0_86 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC87 BL_87 BL__86 GDL_87 PG0_87 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC88 BL_88 BL__87 GDL_88 PG0_88 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC89 BL_89 BL__88 GDL_89 PG0_89 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC90 BL_90 BL__89 GDL_90 PG0_90 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC91 BL_91 BL__90 GDL_91 PG0_91 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC92 BL_92 BL__91 GDL_92 PG0_92 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC93 BL_93 BL__92 GDL_93 PG0_93 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC94 BL_94 BL__93 GDL_94 PG0_94 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC95 BL_95 BL__94 GDL_95 PG0_95 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC96 BL_96 BL__95 GDL_96 PG0_96 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC97 BL_97 BL__96 GDL_97 PG0_97 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC98 BL_98 BL__97 GDL_98 PG0_98 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC99 BL_99 BL__98 GDL_99 PG0_99 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16CC_ROW128RO
****
.SUBCKT lut_sram_1024x16CC_ROW128RE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25
+  GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55
+  GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65
+  GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75
+  GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85
+  GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95
+  GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105
+  GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114
+  GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123
+  GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3
+  PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14
+  PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24
+  PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34
+  PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44
+  PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54
+  PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64
+  PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74
+  PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84
+  PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94
+  PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104
+  PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113
+  PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122
+  PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL VSSE
+  VDDPE VDDCE
** lut_sram_1024x16CC_ROW128RE: 774 flat devices **
XCC1 BL_1 BL__0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC10 BL_10 BL__9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC100 BL_100 BL__99 GDL_100 PG0_100 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC101 BL_101 BL__100 GDL_101 PG0_101 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC102 BL_102 BL__101 GDL_102 PG0_102 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC103 BL_103 BL__102 GDL_103 PG0_103 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC104 BL_104 BL__103 GDL_104 PG0_104 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC105 BL_105 BL__104 GDL_105 PG0_105 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC106 BL_106 BL__105 GDL_106 PG0_106 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC107 BL_107 BL__106 GDL_107 PG0_107 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC108 BL_108 BL__107 GDL_108 PG0_108 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC109 BL_109 BL__108 GDL_109 PG0_109 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC11 BL_11 BL__10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC110 BL_110 BL__109 GDL_110 PG0_110 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC111 BL_111 BL__110 GDL_111 PG0_111 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC112 BL_112 BL__111 GDL_112 PG0_112 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC113 BL_113 BL__112 GDL_113 PG0_113 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC114 BL_114 BL__113 GDL_114 PG0_114 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC115 BL_115 BL__114 GDL_115 PG0_115 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC116 BL_116 BL__115 GDL_116 PG0_116 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC117 BL_117 BL__116 GDL_117 PG0_117 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC118 BL_118 BL__117 GDL_118 PG0_118 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC119 BL_119 BL__118 GDL_119 PG0_119 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC12 BL_12 BL__11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC120 BL_120 BL__119 GDL_120 PG0_120 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC121 BL_121 BL__120 GDL_121 PG0_121 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC122 BL_122 BL__121 GDL_122 PG0_122 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC123 BL_123 BL__122 GDL_123 PG0_123 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC124 BL_124 BL__123 GDL_124 PG0_124 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC125 BL_125 BL__124 GDL_125 PG0_125 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC126 BL_126 BL__125 GDL_126 PG0_126 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC127 BL_127 BL__126 GDL_127 PG0_127 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC128 BL_128 BL__127 GDL_128 PG0_128 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC13 BL_13 BL__12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC14 BL_14 BL__13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC15 BL_15 BL__14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC16 BL_16 BL__15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC17 BL_17 BL__16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC18 BL_18 BL__17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC19 BL_19 BL__18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC2 BL_2 BL__1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC20 BL_20 BL__19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC21 BL_21 BL__20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC22 BL_22 BL__21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC23 BL_23 BL__22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC24 BL_24 BL__23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC25 BL_25 BL__24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC26 BL_26 BL__25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC27 BL_27 BL__26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC28 BL_28 BL__27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC29 BL_29 BL__28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC3 BL_3 BL__2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC30 BL_30 BL__29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC31 BL_31 BL__30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC32 BL_32 BL__31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC33 BL_33 BL__32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC34 BL_34 BL__33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC35 BL_35 BL__34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC36 BL_36 BL__35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC37 BL_37 BL__36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC38 BL_38 BL__37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC39 BL_39 BL__38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC4 BL_4 BL__3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC40 BL_40 BL__39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC41 BL_41 BL__40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC42 BL_42 BL__41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC43 BL_43 BL__42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC44 BL_44 BL__43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC45 BL_45 BL__44 GDL_45 PG0_45 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC46 BL_46 BL__45 GDL_46 PG0_46 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC47 BL_47 BL__46 GDL_47 PG0_47 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC48 BL_48 BL__47 GDL_48 PG0_48 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC49 BL_49 BL__48 GDL_49 PG0_49 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC5 BL_5 BL__4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC50 BL_50 BL__49 GDL_50 PG0_50 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC51 BL_51 BL__50 GDL_51 PG0_51 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC52 BL_52 BL__51 GDL_52 PG0_52 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC53 BL_53 BL__52 GDL_53 PG0_53 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC54 BL_54 BL__53 GDL_54 PG0_54 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC55 BL_55 BL__54 GDL_55 PG0_55 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC56 BL_56 BL__55 GDL_56 PG0_56 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC57 BL_57 BL__56 GDL_57 PG0_57 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC58 BL_58 BL__57 GDL_58 PG0_58 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC59 BL_59 BL__58 GDL_59 PG0_59 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC6 BL_6 BL__5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC60 BL_60 BL__59 GDL_60 PG0_60 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC61 BL_61 BL__60 GDL_61 PG0_61 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC62 BL_62 BL__61 GDL_62 PG0_62 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC63 BL_63 BL__62 GDL_63 PG0_63 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC64 BL_64 BL__63 GDL_64 PG0_64 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC65 BL_65 BL__64 GDL_65 PG0_65 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC66 BL_66 BL__65 GDL_66 PG0_66 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC67 BL_67 BL__66 GDL_67 PG0_67 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC68 BL_68 BL__67 GDL_68 PG0_68 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC69 BL_69 BL__68 GDL_69 PG0_69 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC7 BL_7 BL__6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC70 BL_70 BL__69 GDL_70 PG0_70 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC71 BL_71 BL__70 GDL_71 PG0_71 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC72 BL_72 BL__71 GDL_72 PG0_72 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC73 BL_73 BL__72 GDL_73 PG0_73 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC74 BL_74 BL__73 GDL_74 PG0_74 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC75 BL_75 BL__74 GDL_75 PG0_75 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC76 BL_76 BL__75 GDL_76 PG0_76 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC77 BL_77 BL__76 GDL_77 PG0_77 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC78 BL_78 BL__77 GDL_78 PG0_78 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC79 BL_79 BL__78 GDL_79 PG0_79 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC8 BL_8 BL__7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC80 BL_80 BL__79 GDL_80 PG0_80 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC81 BL_81 BL__80 GDL_81 PG0_81 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC82 BL_82 BL__81 GDL_82 PG0_82 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC83 BL_83 BL__82 GDL_83 PG0_83 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC84 BL_84 BL__83 GDL_84 PG0_84 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC85 BL_85 BL__84 GDL_85 PG0_85 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC86 BL_86 BL__85 GDL_86 PG0_86 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC87 BL_87 BL__86 GDL_87 PG0_87 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC88 BL_88 BL__87 GDL_88 PG0_88 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC89 BL_89 BL__88 GDL_89 PG0_89 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC9 BL_9 BL__8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE lut_sram_1024x16WRAPPED_CC
XCC90 BL_90 BL__89 GDL_90 PG0_90 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC91 BL_91 BL__90 GDL_91 PG0_91 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC92 BL_92 BL__91 GDL_92 PG0_92 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC93 BL_93 BL__92 GDL_93 PG0_93 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC94 BL_94 BL__93 GDL_94 PG0_94 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC95 BL_95 BL__94 GDL_95 PG0_95 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC96 BL_96 BL__95 GDL_96 PG0_96 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC97 BL_97 BL__96 GDL_97 PG0_97 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC98 BL_98 BL__97 GDL_98 PG0_98 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XCC99 BL_99 BL__98 GDL_99 PG0_99 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16WRAPPED_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16CC_ROW128RE
****
.SUBCKT lut_sram_1024x16MWL_ROW128RO BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3
+  DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12
+  DIFF1_13 DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20
+  DIFF1_21 DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28
+  DIFF1_29 DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36
+  DIFF1_37 DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44
+  DIFF1_45 DIFF1_46 DIFF1_47 DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52
+  DIFF1_53 DIFF1_54 DIFF1_55 DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60
+  DIFF1_61 DIFF1_62 DIFF1_63 DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68
+  DIFF1_69 DIFF1_70 DIFF1_71 DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76
+  DIFF1_77 DIFF1_78 DIFF1_79 DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84
+  DIFF1_85 DIFF1_86 DIFF1_87 DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92
+  DIFF1_93 DIFF1_94 DIFF1_95 DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100
+  DIFF1_101 DIFF1_102 DIFF1_103 DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107
+  DIFF1_108 DIFF1_109 DIFF1_110 DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114
+  DIFF1_115 DIFF1_116 DIFF1_117 DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121
+  DIFF1_122 DIFF1_123 DIFF1_124 DIFF1_125 DIFF1_126 DIFF1_127 DIFF2_0 DIFF2_1
+  DIFF2_2 DIFF2_3 DIFF2_4 DIFF2_5 DIFF2_6 DIFF2_7 DIFF2_8 DIFF2_9 DIFF2_10
+  DIFF2_11 DIFF2_12 DIFF2_13 DIFF2_14 DIFF2_15 DIFF2_16 DIFF2_17 DIFF2_18
+  DIFF2_19 DIFF2_20 DIFF2_21 DIFF2_22 DIFF2_23 DIFF2_24 DIFF2_25 DIFF2_26
+  DIFF2_27 DIFF2_28 DIFF2_29 DIFF2_30 DIFF2_31 DIFF2_32 DIFF2_33 DIFF2_34
+  DIFF2_35 DIFF2_36 DIFF2_37 DIFF2_38 DIFF2_39 DIFF2_40 DIFF2_41 DIFF2_42
+  DIFF2_43 DIFF2_44 DIFF2_45 DIFF2_46 DIFF2_47 DIFF2_48 DIFF2_49 DIFF2_50
+  DIFF2_51 DIFF2_52 DIFF2_53 DIFF2_54 DIFF2_55 DIFF2_56 DIFF2_57 DIFF2_58
+  DIFF2_59 DIFF2_60 DIFF2_61 DIFF2_62 DIFF2_63 DIFF2_64 DIFF2_65 DIFF2_66
+  DIFF2_67 DIFF2_68 DIFF2_69 DIFF2_70 DIFF2_71 DIFF2_72 DIFF2_73 DIFF2_74
+  DIFF2_75 DIFF2_76 DIFF2_77 DIFF2_78 DIFF2_79 DIFF2_80 DIFF2_81 DIFF2_82
+  DIFF2_83 DIFF2_84 DIFF2_85 DIFF2_86 DIFF2_87 DIFF2_88 DIFF2_89 DIFF2_90
+  DIFF2_91 DIFF2_92 DIFF2_93 DIFF2_94 DIFF2_95 DIFF2_96 DIFF2_97 DIFF2_98
+  DIFF2_99 DIFF2_100 DIFF2_101 DIFF2_102 DIFF2_103 DIFF2_104 DIFF2_105
+  DIFF2_106 DIFF2_107 DIFF2_108 DIFF2_109 DIFF2_110 DIFF2_111 DIFF2_112
+  DIFF2_113 DIFF2_114 DIFF2_115 DIFF2_116 DIFF2_117 DIFF2_118 DIFF2_119
+  DIFF2_120 DIFF2_121 DIFF2_122 DIFF2_123 DIFF2_124 DIFF2_125 DIFF2_126
+  DIFF2_127 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89
+  GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99
+  GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108
+  GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117
+  GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126
+  GDL_127 GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL1 VSSE VDDPE VDDCE
** lut_sram_1024x16MWL_ROW128RO: 774 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 DIFF2_0 GDL_1 PG0_1 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC10 BL_10 BL__9 DIFF1_9 DIFF2_9 GDL_10 PG0_10 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC100 BL_100 BL__99 DIFF1_99 DIFF2_99 GDL_100 PG0_100 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC101 BL_101 BL__100 DIFF1_100 DIFF2_100 GDL_101 PG0_101 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC102 BL_102 BL__101 DIFF1_101 DIFF2_101 GDL_102 PG0_102 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC103 BL_103 BL__102 DIFF1_102 DIFF2_102 GDL_103 PG0_103 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC104 BL_104 BL__103 DIFF1_103 DIFF2_103 GDL_104 PG0_104 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC105 BL_105 BL__104 DIFF1_104 DIFF2_104 GDL_105 PG0_105 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC106 BL_106 BL__105 DIFF1_105 DIFF2_105 GDL_106 PG0_106 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC107 BL_107 BL__106 DIFF1_106 DIFF2_106 GDL_107 PG0_107 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC108 BL_108 BL__107 DIFF1_107 DIFF2_107 GDL_108 PG0_108 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC109 BL_109 BL__108 DIFF1_108 DIFF2_108 GDL_109 PG0_109 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC11 BL_11 BL__10 DIFF1_10 DIFF2_10 GDL_11 PG0_11 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC110 BL_110 BL__109 DIFF1_109 DIFF2_109 GDL_110 PG0_110 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC111 BL_111 BL__110 DIFF1_110 DIFF2_110 GDL_111 PG0_111 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC112 BL_112 BL__111 DIFF1_111 DIFF2_111 GDL_112 PG0_112 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC113 BL_113 BL__112 DIFF1_112 DIFF2_112 GDL_113 PG0_113 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC114 BL_114 BL__113 DIFF1_113 DIFF2_113 GDL_114 PG0_114 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC115 BL_115 BL__114 DIFF1_114 DIFF2_114 GDL_115 PG0_115 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC116 BL_116 BL__115 DIFF1_115 DIFF2_115 GDL_116 PG0_116 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC117 BL_117 BL__116 DIFF1_116 DIFF2_116 GDL_117 PG0_117 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC118 BL_118 BL__117 DIFF1_117 DIFF2_117 GDL_118 PG0_118 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC119 BL_119 BL__118 DIFF1_118 DIFF2_118 GDL_119 PG0_119 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC12 BL_12 BL__11 DIFF1_11 DIFF2_11 GDL_12 PG0_12 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC120 BL_120 BL__119 DIFF1_119 DIFF2_119 GDL_120 PG0_120 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC121 BL_121 BL__120 DIFF1_120 DIFF2_120 GDL_121 PG0_121 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC122 BL_122 BL__121 DIFF1_121 DIFF2_121 GDL_122 PG0_122 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC123 BL_123 BL__122 DIFF1_122 DIFF2_122 GDL_123 PG0_123 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC124 BL_124 BL__123 DIFF1_123 DIFF2_123 GDL_124 PG0_124 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC125 BL_125 BL__124 DIFF1_124 DIFF2_124 GDL_125 PG0_125 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC126 BL_126 BL__125 DIFF1_125 DIFF2_125 GDL_126 PG0_126 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC127 BL_127 BL__126 DIFF1_126 DIFF2_126 GDL_127 PG0_127 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC128 BL_128 BL__127 DIFF1_127 DIFF2_127 GDL_128 PG0_128 TL0_1 VSSE VDDPE
+  VDDCE lut_sram_1024x16MWL_CC
XCC13 BL_13 BL__12 DIFF1_12 DIFF2_12 GDL_13 PG0_13 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC14 BL_14 BL__13 DIFF1_13 DIFF2_13 GDL_14 PG0_14 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC15 BL_15 BL__14 DIFF1_14 DIFF2_14 GDL_15 PG0_15 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC16 BL_16 BL__15 DIFF1_15 DIFF2_15 GDL_16 PG0_16 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC17 BL_17 BL__16 DIFF1_16 DIFF2_16 GDL_17 PG0_17 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC18 BL_18 BL__17 DIFF1_17 DIFF2_17 GDL_18 PG0_18 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC19 BL_19 BL__18 DIFF1_18 DIFF2_18 GDL_19 PG0_19 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC2 BL_2 BL__1 DIFF1_1 DIFF2_1 GDL_2 PG0_2 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC20 BL_20 BL__19 DIFF1_19 DIFF2_19 GDL_20 PG0_20 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC21 BL_21 BL__20 DIFF1_20 DIFF2_20 GDL_21 PG0_21 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC22 BL_22 BL__21 DIFF1_21 DIFF2_21 GDL_22 PG0_22 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC23 BL_23 BL__22 DIFF1_22 DIFF2_22 GDL_23 PG0_23 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC24 BL_24 BL__23 DIFF1_23 DIFF2_23 GDL_24 PG0_24 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC25 BL_25 BL__24 DIFF1_24 DIFF2_24 GDL_25 PG0_25 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC26 BL_26 BL__25 DIFF1_25 DIFF2_25 GDL_26 PG0_26 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC27 BL_27 BL__26 DIFF1_26 DIFF2_26 GDL_27 PG0_27 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC28 BL_28 BL__27 DIFF1_27 DIFF2_27 GDL_28 PG0_28 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC29 BL_29 BL__28 DIFF1_28 DIFF2_28 GDL_29 PG0_29 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC3 BL_3 BL__2 DIFF1_2 DIFF2_2 GDL_3 PG0_3 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC30 BL_30 BL__29 DIFF1_29 DIFF2_29 GDL_30 PG0_30 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC31 BL_31 BL__30 DIFF1_30 DIFF2_30 GDL_31 PG0_31 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC32 BL_32 BL__31 DIFF1_31 DIFF2_31 GDL_32 PG0_32 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC33 BL_33 BL__32 DIFF1_32 DIFF2_32 GDL_33 PG0_33 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC34 BL_34 BL__33 DIFF1_33 DIFF2_33 GDL_34 PG0_34 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC35 BL_35 BL__34 DIFF1_34 DIFF2_34 GDL_35 PG0_35 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC36 BL_36 BL__35 DIFF1_35 DIFF2_35 GDL_36 PG0_36 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC37 BL_37 BL__36 DIFF1_36 DIFF2_36 GDL_37 PG0_37 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC38 BL_38 BL__37 DIFF1_37 DIFF2_37 GDL_38 PG0_38 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC39 BL_39 BL__38 DIFF1_38 DIFF2_38 GDL_39 PG0_39 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC4 BL_4 BL__3 DIFF1_3 DIFF2_3 GDL_4 PG0_4 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC40 BL_40 BL__39 DIFF1_39 DIFF2_39 GDL_40 PG0_40 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC41 BL_41 BL__40 DIFF1_40 DIFF2_40 GDL_41 PG0_41 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC42 BL_42 BL__41 DIFF1_41 DIFF2_41 GDL_42 PG0_42 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC43 BL_43 BL__42 DIFF1_42 DIFF2_42 GDL_43 PG0_43 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC44 BL_44 BL__43 DIFF1_43 DIFF2_43 GDL_44 PG0_44 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC45 BL_45 BL__44 DIFF1_44 DIFF2_44 GDL_45 PG0_45 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC46 BL_46 BL__45 DIFF1_45 DIFF2_45 GDL_46 PG0_46 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC47 BL_47 BL__46 DIFF1_46 DIFF2_46 GDL_47 PG0_47 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC48 BL_48 BL__47 DIFF1_47 DIFF2_47 GDL_48 PG0_48 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC49 BL_49 BL__48 DIFF1_48 DIFF2_48 GDL_49 PG0_49 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC5 BL_5 BL__4 DIFF1_4 DIFF2_4 GDL_5 PG0_5 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC50 BL_50 BL__49 DIFF1_49 DIFF2_49 GDL_50 PG0_50 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC51 BL_51 BL__50 DIFF1_50 DIFF2_50 GDL_51 PG0_51 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC52 BL_52 BL__51 DIFF1_51 DIFF2_51 GDL_52 PG0_52 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC53 BL_53 BL__52 DIFF1_52 DIFF2_52 GDL_53 PG0_53 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC54 BL_54 BL__53 DIFF1_53 DIFF2_53 GDL_54 PG0_54 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC55 BL_55 BL__54 DIFF1_54 DIFF2_54 GDL_55 PG0_55 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC56 BL_56 BL__55 DIFF1_55 DIFF2_55 GDL_56 PG0_56 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC57 BL_57 BL__56 DIFF1_56 DIFF2_56 GDL_57 PG0_57 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC58 BL_58 BL__57 DIFF1_57 DIFF2_57 GDL_58 PG0_58 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC59 BL_59 BL__58 DIFF1_58 DIFF2_58 GDL_59 PG0_59 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC6 BL_6 BL__5 DIFF1_5 DIFF2_5 GDL_6 PG0_6 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC60 BL_60 BL__59 DIFF1_59 DIFF2_59 GDL_60 PG0_60 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC61 BL_61 BL__60 DIFF1_60 DIFF2_60 GDL_61 PG0_61 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC62 BL_62 BL__61 DIFF1_61 DIFF2_61 GDL_62 PG0_62 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC63 BL_63 BL__62 DIFF1_62 DIFF2_62 GDL_63 PG0_63 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC64 BL_64 BL__63 DIFF1_63 DIFF2_63 GDL_64 PG0_64 TL0_1 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16FLMW
XCC65 BL_65 BL__64 DIFF1_64 DIFF2_64 GDL_65 PG0_65 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC66 BL_66 BL__65 DIFF1_65 DIFF2_65 GDL_66 PG0_66 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC67 BL_67 BL__66 DIFF1_66 DIFF2_66 GDL_67 PG0_67 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC68 BL_68 BL__67 DIFF1_67 DIFF2_67 GDL_68 PG0_68 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC69 BL_69 BL__68 DIFF1_68 DIFF2_68 GDL_69 PG0_69 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC7 BL_7 BL__6 DIFF1_6 DIFF2_6 GDL_7 PG0_7 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC70 BL_70 BL__69 DIFF1_69 DIFF2_69 GDL_70 PG0_70 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC71 BL_71 BL__70 DIFF1_70 DIFF2_70 GDL_71 PG0_71 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC72 BL_72 BL__71 DIFF1_71 DIFF2_71 GDL_72 PG0_72 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC73 BL_73 BL__72 DIFF1_72 DIFF2_72 GDL_73 PG0_73 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC74 BL_74 BL__73 DIFF1_73 DIFF2_73 GDL_74 PG0_74 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC75 BL_75 BL__74 DIFF1_74 DIFF2_74 GDL_75 PG0_75 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC76 BL_76 BL__75 DIFF1_75 DIFF2_75 GDL_76 PG0_76 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC77 BL_77 BL__76 DIFF1_76 DIFF2_76 GDL_77 PG0_77 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC78 BL_78 BL__77 DIFF1_77 DIFF2_77 GDL_78 PG0_78 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC79 BL_79 BL__78 DIFF1_78 DIFF2_78 GDL_79 PG0_79 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC8 BL_8 BL__7 DIFF1_7 DIFF2_7 GDL_8 PG0_8 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC80 BL_80 BL__79 DIFF1_79 DIFF2_79 GDL_80 PG0_80 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC81 BL_81 BL__80 DIFF1_80 DIFF2_80 GDL_81 PG0_81 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC82 BL_82 BL__81 DIFF1_81 DIFF2_81 GDL_82 PG0_82 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC83 BL_83 BL__82 DIFF1_82 DIFF2_82 GDL_83 PG0_83 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC84 BL_84 BL__83 DIFF1_83 DIFF2_83 GDL_84 PG0_84 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC85 BL_85 BL__84 DIFF1_84 DIFF2_84 GDL_85 PG0_85 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC86 BL_86 BL__85 DIFF1_85 DIFF2_85 GDL_86 PG0_86 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC87 BL_87 BL__86 DIFF1_86 DIFF2_86 GDL_87 PG0_87 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC88 BL_88 BL__87 DIFF1_87 DIFF2_87 GDL_88 PG0_88 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC89 BL_89 BL__88 DIFF1_88 DIFF2_88 GDL_89 PG0_89 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC9 BL_9 BL__8 DIFF1_8 DIFF2_8 GDL_9 PG0_9 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC90 BL_90 BL__89 DIFF1_89 DIFF2_89 GDL_90 PG0_90 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC91 BL_91 BL__90 DIFF1_90 DIFF2_90 GDL_91 PG0_91 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC92 BL_92 BL__91 DIFF1_91 DIFF2_91 GDL_92 PG0_92 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC93 BL_93 BL__92 DIFF1_92 DIFF2_92 GDL_93 PG0_93 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC94 BL_94 BL__93 DIFF1_93 DIFF2_93 GDL_94 PG0_94 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC95 BL_95 BL__94 DIFF1_94 DIFF2_94 GDL_95 PG0_95 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC96 BL_96 BL__95 DIFF1_95 DIFF2_95 GDL_96 PG0_96 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC97 BL_97 BL__96 DIFF1_96 DIFF2_96 GDL_97 PG0_97 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC98 BL_98 BL__97 DIFF1_97 DIFF2_97 GDL_98 PG0_98 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XCC99 BL_99 BL__98 DIFF1_98 DIFF2_98 GDL_99 PG0_99 TL0_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16MWL_CC
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL1 VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16MWL_ROW128RO
****
.SUBCKT lut_sram_1024x16CAPBK_ROW128RE BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 CCMBL DIFF DIFF1_0 DIFF1_1 DIFF1_2 DIFF1_3
+  DIFF1_4 DIFF1_5 DIFF1_6 DIFF1_7 DIFF1_8 DIFF1_9 DIFF1_10 DIFF1_11 DIFF1_12
+  DIFF1_13 DIFF1_14 DIFF1_15 DIFF1_16 DIFF1_17 DIFF1_18 DIFF1_19 DIFF1_20
+  DIFF1_21 DIFF1_22 DIFF1_23 DIFF1_24 DIFF1_25 DIFF1_26 DIFF1_27 DIFF1_28
+  DIFF1_29 DIFF1_30 DIFF1_31 DIFF1_32 DIFF1_33 DIFF1_34 DIFF1_35 DIFF1_36
+  DIFF1_37 DIFF1_38 DIFF1_39 DIFF1_40 DIFF1_41 DIFF1_42 DIFF1_43 DIFF1_44
+  DIFF1_45 DIFF1_46 DIFF1_47 DIFF1_48 DIFF1_49 DIFF1_50 DIFF1_51 DIFF1_52
+  DIFF1_53 DIFF1_54 DIFF1_55 DIFF1_56 DIFF1_57 DIFF1_58 DIFF1_59 DIFF1_60
+  DIFF1_61 DIFF1_62 DIFF1_63 DIFF1_64 DIFF1_65 DIFF1_66 DIFF1_67 DIFF1_68
+  DIFF1_69 DIFF1_70 DIFF1_71 DIFF1_72 DIFF1_73 DIFF1_74 DIFF1_75 DIFF1_76
+  DIFF1_77 DIFF1_78 DIFF1_79 DIFF1_80 DIFF1_81 DIFF1_82 DIFF1_83 DIFF1_84
+  DIFF1_85 DIFF1_86 DIFF1_87 DIFF1_88 DIFF1_89 DIFF1_90 DIFF1_91 DIFF1_92
+  DIFF1_93 DIFF1_94 DIFF1_95 DIFF1_96 DIFF1_97 DIFF1_98 DIFF1_99 DIFF1_100
+  DIFF1_101 DIFF1_102 DIFF1_103 DIFF1_104 DIFF1_105 DIFF1_106 DIFF1_107
+  DIFF1_108 DIFF1_109 DIFF1_110 DIFF1_111 DIFF1_112 DIFF1_113 DIFF1_114
+  DIFF1_115 DIFF1_116 DIFF1_117 DIFF1_118 DIFF1_119 DIFF1_120 DIFF1_121
+  DIFF1_122 DIFF1_123 DIFF1_124 DIFF1_125 DIFF1_126 DIFF1_127 GDL_0 GDL_1
+  GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53
+  GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63
+  GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73
+  GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83
+  GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93
+  GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103
+  GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112
+  GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121
+  GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 NDIFF PDIFF PG0_0
+  PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12
+  PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22
+  PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32
+  PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42
+  PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52
+  PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62
+  PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72
+  PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82
+  PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92
+  PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102
+  PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111
+  PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120
+  PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1
+  TL1 WL VSSE VDDPE VDDCE
** lut_sram_1024x16CAPBK_ROW128RE: 774 flat devices **
XCC1 BL_1 BL__0 DIFF1_0 GDL_1 PG0_1 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC10 BL_10 BL__9 DIFF1_9 GDL_10 PG0_10 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC100 BL_100 BL__99 DIFF1_99 GDL_100 PG0_100 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC101 BL_101 BL__100 DIFF1_100 GDL_101 PG0_101 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC102 BL_102 BL__101 DIFF1_101 GDL_102 PG0_102 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC103 BL_103 BL__102 DIFF1_102 GDL_103 PG0_103 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC104 BL_104 BL__103 DIFF1_103 GDL_104 PG0_104 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC105 BL_105 BL__104 DIFF1_104 GDL_105 PG0_105 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC106 BL_106 BL__105 DIFF1_105 GDL_106 PG0_106 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC107 BL_107 BL__106 DIFF1_106 GDL_107 PG0_107 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC108 BL_108 BL__107 DIFF1_107 GDL_108 PG0_108 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC109 BL_109 BL__108 DIFF1_108 GDL_109 PG0_109 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC11 BL_11 BL__10 DIFF1_10 GDL_11 PG0_11 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC110 BL_110 BL__109 DIFF1_109 GDL_110 PG0_110 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC111 BL_111 BL__110 DIFF1_110 GDL_111 PG0_111 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC112 BL_112 BL__111 DIFF1_111 GDL_112 PG0_112 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC113 BL_113 BL__112 DIFF1_112 GDL_113 PG0_113 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC114 BL_114 BL__113 DIFF1_113 GDL_114 PG0_114 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC115 BL_115 BL__114 DIFF1_114 GDL_115 PG0_115 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC116 BL_116 BL__115 DIFF1_115 GDL_116 PG0_116 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC117 BL_117 BL__116 DIFF1_116 GDL_117 PG0_117 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC118 BL_118 BL__117 DIFF1_117 GDL_118 PG0_118 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC119 BL_119 BL__118 DIFF1_118 GDL_119 PG0_119 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC12 BL_12 BL__11 DIFF1_11 GDL_12 PG0_12 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC120 BL_120 BL__119 DIFF1_119 GDL_120 PG0_120 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC121 BL_121 BL__120 DIFF1_120 GDL_121 PG0_121 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC122 BL_122 BL__121 DIFF1_121 GDL_122 PG0_122 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC123 BL_123 BL__122 DIFF1_122 GDL_123 PG0_123 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC124 BL_124 BL__123 DIFF1_123 GDL_124 PG0_124 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC125 BL_125 BL__124 DIFF1_124 GDL_125 PG0_125 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC126 BL_126 BL__125 DIFF1_125 GDL_126 PG0_126 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC127 BL_127 BL__126 DIFF1_126 GDL_127 PG0_127 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC128 BL_128 BL__127 DIFF1_127 GDL_128 PG0_128 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC13 BL_13 BL__12 DIFF1_12 GDL_13 PG0_13 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC14 BL_14 BL__13 DIFF1_13 GDL_14 PG0_14 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC15 BL_15 BL__14 DIFF1_14 GDL_15 PG0_15 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC16 BL_16 BL__15 DIFF1_15 GDL_16 PG0_16 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC17 BL_17 BL__16 DIFF1_16 GDL_17 PG0_17 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC18 BL_18 BL__17 DIFF1_17 GDL_18 PG0_18 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC19 BL_19 BL__18 DIFF1_18 GDL_19 PG0_19 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC2 BL_2 BL__1 DIFF1_1 GDL_2 PG0_2 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC20 BL_20 BL__19 DIFF1_19 GDL_20 PG0_20 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC21 BL_21 BL__20 DIFF1_20 GDL_21 PG0_21 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC22 BL_22 BL__21 DIFF1_21 GDL_22 PG0_22 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC23 BL_23 BL__22 DIFF1_22 GDL_23 PG0_23 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC24 BL_24 BL__23 DIFF1_23 GDL_24 PG0_24 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC25 BL_25 BL__24 DIFF1_24 GDL_25 PG0_25 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC26 BL_26 BL__25 DIFF1_25 GDL_26 PG0_26 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC27 BL_27 BL__26 DIFF1_26 GDL_27 PG0_27 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC28 BL_28 BL__27 DIFF1_27 GDL_28 PG0_28 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC29 BL_29 BL__28 DIFF1_28 GDL_29 PG0_29 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC3 BL_3 BL__2 DIFF1_2 GDL_3 PG0_3 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC30 BL_30 BL__29 DIFF1_29 GDL_30 PG0_30 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC31 BL_31 BL__30 DIFF1_30 GDL_31 PG0_31 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC32 BL_32 BL__31 DIFF1_31 GDL_32 PG0_32 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC33 BL_33 BL__32 DIFF1_32 GDL_33 PG0_33 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC34 BL_34 BL__33 DIFF1_33 GDL_34 PG0_34 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC35 BL_35 BL__34 DIFF1_34 GDL_35 PG0_35 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC36 BL_36 BL__35 DIFF1_35 GDL_36 PG0_36 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC37 BL_37 BL__36 DIFF1_36 GDL_37 PG0_37 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC38 BL_38 BL__37 DIFF1_37 GDL_38 PG0_38 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC39 BL_39 BL__38 DIFF1_38 GDL_39 PG0_39 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC4 BL_4 BL__3 DIFF1_3 GDL_4 PG0_4 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC40 BL_40 BL__39 DIFF1_39 GDL_40 PG0_40 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC41 BL_41 BL__40 DIFF1_40 GDL_41 PG0_41 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC42 BL_42 BL__41 DIFF1_41 GDL_42 PG0_42 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC43 BL_43 BL__42 DIFF1_42 GDL_43 PG0_43 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC44 BL_44 BL__43 DIFF1_43 GDL_44 PG0_44 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC45 BL_45 BL__44 DIFF1_44 GDL_45 PG0_45 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC46 BL_46 BL__45 DIFF1_45 GDL_46 PG0_46 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC47 BL_47 BL__46 DIFF1_46 GDL_47 PG0_47 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC48 BL_48 BL__47 DIFF1_47 GDL_48 PG0_48 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC49 BL_49 BL__48 DIFF1_48 GDL_49 PG0_49 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC5 BL_5 BL__4 DIFF1_4 GDL_5 PG0_5 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC50 BL_50 BL__49 DIFF1_49 GDL_50 PG0_50 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC51 BL_51 BL__50 DIFF1_50 GDL_51 PG0_51 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC52 BL_52 BL__51 DIFF1_51 GDL_52 PG0_52 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC53 BL_53 BL__52 DIFF1_52 GDL_53 PG0_53 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC54 BL_54 BL__53 DIFF1_53 GDL_54 PG0_54 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC55 BL_55 BL__54 DIFF1_54 GDL_55 PG0_55 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC56 BL_56 BL__55 DIFF1_55 GDL_56 PG0_56 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC57 BL_57 BL__56 DIFF1_56 GDL_57 PG0_57 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC58 BL_58 BL__57 DIFF1_57 GDL_58 PG0_58 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC59 BL_59 BL__58 DIFF1_58 GDL_59 PG0_59 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC6 BL_6 BL__5 DIFF1_5 GDL_6 PG0_6 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC60 BL_60 BL__59 DIFF1_59 GDL_60 PG0_60 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC61 BL_61 BL__60 DIFF1_60 GDL_61 PG0_61 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC62 BL_62 BL__61 DIFF1_61 GDL_62 PG0_62 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC63 BL_63 BL__62 DIFF1_62 GDL_63 PG0_63 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC64 BL_64 BL__63 DIFF1_63 GDL_64 PG0_64 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC65 BL_65 BL__64 DIFF1_64 GDL_65 PG0_65 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC66 BL_66 BL__65 DIFF1_65 GDL_66 PG0_66 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC67 BL_67 BL__66 DIFF1_66 GDL_67 PG0_67 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC68 BL_68 BL__67 DIFF1_67 GDL_68 PG0_68 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC69 BL_69 BL__68 DIFF1_68 GDL_69 PG0_69 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC7 BL_7 BL__6 DIFF1_6 GDL_7 PG0_7 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC70 BL_70 BL__69 DIFF1_69 GDL_70 PG0_70 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC71 BL_71 BL__70 DIFF1_70 GDL_71 PG0_71 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC72 BL_72 BL__71 DIFF1_71 GDL_72 PG0_72 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC73 BL_73 BL__72 DIFF1_72 GDL_73 PG0_73 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC74 BL_74 BL__73 DIFF1_73 GDL_74 PG0_74 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC75 BL_75 BL__74 DIFF1_74 GDL_75 PG0_75 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC76 BL_76 BL__75 DIFF1_75 GDL_76 PG0_76 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC77 BL_77 BL__76 DIFF1_76 GDL_77 PG0_77 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC78 BL_78 BL__77 DIFF1_77 GDL_78 PG0_78 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC79 BL_79 BL__78 DIFF1_78 GDL_79 PG0_79 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC8 BL_8 BL__7 DIFF1_7 GDL_8 PG0_8 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC80 BL_80 BL__79 DIFF1_79 GDL_80 PG0_80 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC81 BL_81 BL__80 DIFF1_80 GDL_81 PG0_81 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC82 BL_82 BL__81 DIFF1_81 GDL_82 PG0_82 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC83 BL_83 BL__82 DIFF1_82 GDL_83 PG0_83 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC84 BL_84 BL__83 DIFF1_83 GDL_84 PG0_84 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC85 BL_85 BL__84 DIFF1_84 GDL_85 PG0_85 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC86 BL_86 BL__85 DIFF1_85 GDL_86 PG0_86 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC87 BL_87 BL__86 DIFF1_86 GDL_87 PG0_87 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC88 BL_88 BL__87 DIFF1_87 GDL_88 PG0_88 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC89 BL_89 BL__88 DIFF1_88 GDL_89 PG0_89 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC9 BL_9 BL__8 DIFF1_8 GDL_9 PG0_9 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC90 BL_90 BL__89 DIFF1_89 GDL_90 PG0_90 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC91 BL_91 BL__90 DIFF1_90 GDL_91 PG0_91 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC92 BL_92 BL__91 DIFF1_91 GDL_92 PG0_92 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC93 BL_93 BL__92 DIFF1_92 GDL_93 PG0_93 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC94 BL_94 BL__93 DIFF1_93 GDL_94 PG0_94 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC95 BL_95 BL__94 DIFF1_94 GDL_95 PG0_95 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC96 BL_96 BL__95 DIFF1_95 GDL_96 PG0_96 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC97 BL_97 BL__96 DIFF1_96 GDL_97 PG0_97 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC98 BL_98 BL__97 DIFF1_97 GDL_98 PG0_98 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XCC99 BL_99 BL__98 DIFF1_98 GDL_99 PG0_99 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCCAPBK
XI0 BL_0 CCMBL DIFF GDL_0 NDIFF PDIFF PG0_0 TL0_0 WL VSSE VDDPE VDDCE
+  lut_sram_1024x16CCEDGE_CCMBL
.ENDS lut_sram_1024x16CAPBK_ROW128RE
****
.SUBCKT lut_sram_1024x16CABR128X64TT BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7
+  BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32
+  BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44
+  BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56
+  BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68
+  BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80
+  BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92
+  BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103
+  BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113
+  BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123
+  BL_124 BL_125 BL_126 BL_127 BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BL__127 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6
+  GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17
+  GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27
+  GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37
+  GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47
+  GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57
+  GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67
+  GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77
+  GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87
+  GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97
+  GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106
+  GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115
+  GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124
+  GDL_125 GDL_126 GDL_127 GDL_128 MBL PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5
+  PG0_6 PG0_7 PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16
+  PG0_17 PG0_18 PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26
+  PG0_27 PG0_28 PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36
+  PG0_37 PG0_38 PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46
+  PG0_47 PG0_48 PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56
+  PG0_57 PG0_58 PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66
+  PG0_67 PG0_68 PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76
+  PG0_77 PG0_78 PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86
+  PG0_87 PG0_88 PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96
+  PG0_97 PG0_98 PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105
+  PG0_106 PG0_107 PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114
+  PG0_115 PG0_116 PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123
+  PG0_124 PG0_125 PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64
+  WL_65 VSSE VDDPE VDDCE
** lut_sram_1024x16CABR128X64TT: 51858 flat devices **
XCC_ROW0 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_683 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_685 PDIFF_687 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_0 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW1 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_683 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_685 PDIFF_689 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_1 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW10 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_595 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_597 PDIFF_599 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_10 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW11 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_595 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_597 PDIFF_601 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_11 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW12 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_607 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_609 PDIFF_601 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_12 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW13 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_607 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_609 PDIFF_613 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_13 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW14 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_623 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_625 PDIFF_613 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_14 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW15 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_623 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_625 PDIFF_631 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_15 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW16 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_641 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_643 PDIFF_631 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_16 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW17 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_641 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_643 PDIFF_649 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_17 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW18 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_659 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_661 PDIFF_649 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_18 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW19 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_659 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_661 PDIFF_667 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_19 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW2 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_691 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_693 PDIFF_689 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_2 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW20 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF PDIFF_667 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_20 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW21 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7 PG0_8
+  PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18 PG0_19
+  PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28 PG0_29
+  PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38 PG0_39
+  PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48 PG0_49
+  PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58 PG0_59
+  PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68 PG0_69
+  PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78 PG0_79
+  PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88 PG0_89
+  PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98 PG0_99
+  PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107 PG0_108
+  PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116 PG0_117
+  PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125 PG0_126
+  PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_21 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW22 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_11 PDIFF PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_22 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW23 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_9 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_11 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_23 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW24 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_29 PDIFF_15 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_24 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW25 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_27 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_29 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_25 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW26 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_47 PDIFF_35 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_26 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW27 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_45 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_47 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_27 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW28 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_61 PDIFF_53 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_28 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW29 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_59 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_61 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_29 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW3 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_691 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_693 PDIFF_695 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_3 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW30 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_603 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_605 PDIFF_65 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_30 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW31 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_603 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_605 PDIFF_611 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_31 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW32 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_615 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_617 PDIFF_611 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_32 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW33 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_615 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_617 PDIFF_627 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_33 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW34 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_633 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_635 PDIFF_627 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_34 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW35 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_633 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_635 PDIFF_645 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_35 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW36 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_651 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_653 PDIFF_645 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_36 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW37 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_651 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_653 PDIFF_663 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_37 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW38 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_669 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_671 PDIFF_663 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_38 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW39 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_669 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_671 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_39 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW4 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_697 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_699 PDIFF_695 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_4 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW40 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_5 PDIFF_7 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_40 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW41 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_5 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_41 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW42 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_19 PDIFF_13 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_42 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW43 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_17 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_19 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_43 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW44 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_39 PDIFF_31 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_44 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW45 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_37 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_39 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_45 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW46 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_57 PDIFF_49 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_46 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW47 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_55 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_57 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_47 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW48 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_69 PDIFF_63 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_48 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW49 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_67 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_69 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_49 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW5 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_697 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_699 PDIFF_701 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_5 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW50 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_619 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_621 PDIFF_71 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_50 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW51 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_619 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_621 PDIFF_629 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_51 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW52 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_637 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_639 PDIFF_629 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_52 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW53 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_637 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_639 PDIFF_647 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_53 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW54 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_655 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_657 PDIFF_647 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_54 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW55 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_655 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_657 PDIFF_665 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_55 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW56 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_673 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_675 PDIFF_665 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_56 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW57 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_673 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_675 PDIFF_677 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_57 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RO
XCC_ROW58 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
+  BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96
+  BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107
+  BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117
+  BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_127
+  BL_128 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 BL__127 MBL
+  DIFF_679 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 NDIFF_681 PDIFF_677 PG0_0 PG0_1 PG0_2 PG0_3 PG0_4 PG0_5 PG0_6 PG0_7
+  PG0_8 PG0_9 PG0_10 PG0_11 PG0_12 PG0_13 PG0_14 PG0_15 PG0_16 PG0_17 PG0_18
+  PG0_19 PG0_20 PG0_21 PG0_22 PG0_23 PG0_24 PG0_25 PG0_26 PG0_27 PG0_28
+  PG0_29 PG0_30 PG0_31 PG0_32 PG0_33 PG0_34 PG0_35 PG0_36 PG0_37 PG0_38
+  PG0_39 PG0_40 PG0_41 PG0_42 PG0_43 PG0_44 PG0_45 PG0_46 PG0_47 PG0_48
+  PG0_49 PG0_50 PG0_51 PG0_52 PG0_53 PG0_54 PG0_55 PG0_56 PG0_57 PG0_58
+  PG0_59 PG0_60 PG0_61 PG0_62 PG0_63 PG0_64 PG0_65 PG0_66 PG0_67 PG0_68
+  PG0_69 PG0_70 PG0_71 PG0_72 PG0_73 PG0_74 PG0_75 PG0_76 PG0_77 PG0_78
+  PG0_79 PG0_80 PG0_81 PG0_82 PG0_83 PG0_84 PG0_85 PG0_86 PG0_87 PG0_88
+  PG0_89 PG0_90 PG0_91 PG0_92 PG0_93 PG0_94 PG0_95 PG0_96 PG0_97 PG0_98
+  PG0_99 PG0_100 PG0_101 PG0_102 PG0_103 PG0_104 PG0_105 PG0_106 PG0_107
+  PG0_108 PG0_109 PG0_110 PG0_111 PG0_112 PG0_113 PG0_114 PG0_115 PG0_116
+  PG0_117 PG0_118 PG0_119 PG0_120 PG0_121 PG0_122 PG0_123 PG0_124 PG0_125
+  PG0_126 PG0_127 PG0_128 TL0_0 TL0_1 TL1 WL_58 VSSE VDDPE VDDCE
+  lut_sram_1024x16CC_ROW128RE
XCC_ROW59 BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12
+  BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24
+  BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48
+  BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60
+  BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72
+  BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84
