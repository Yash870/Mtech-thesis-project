* 
* Copyright 2026 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.4.15
* Version: r0p1-00eac0
* Name: sram_dp_hdc_svt_rvt_hvt Compiler|TSMC cln65gplus 65nm Process, 0.974um2 Bitcell
* Comment: 
* Configuration:  -instname "pe_spad_1024x16_dp" -words 1024 -bits \
* Configuration: 16 -frequency 100 -mux 16 -pipeline off -write_mas\
* Configuration: k off -wp_size 8 -write_thru on -top_layer "m5-m9"\
* Configuration:  -power_type otc -redundancy off -rcols 2 -rrows 2\
* Configuration:  -bmux off -ser none -back_biasing off -power_gati\
* Configuration: ng off -retention on -ema on -atf off -cust_commen\
* Configuration: t "" -bus_notation on -left_bus_delim "[" -right_b\
* Configuration: us_delim "]" -pwr_gnd_rename "VDDPE:VDDPE,VDDCE:VD\
* Configuration: DCE,VSSE:VSSE" -prefix "" -name_case upper -check_\
* Configuration: instname off -diodes on -drive 6 -dnw off -dpccm o\
* Configuration: n -asvm on -corners ff_1p10v_1p10v_125c,tt_1p00v_1\
* Configuration: p00v_25c,ff_1p10v_1p10v_0c,ss_0p90v_0p90v_125c,ff_\
* Configuration: 1p10v_1p10v_m40c,ss_0p90v_0p90v_m40c
* Codefile: 
* 
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT pe_spad_1024x16_dpFPIO4 BWEA BWEB BWENA BWENB CRENA CRENAM CRENB
+  CRENBM DA DB DNA DNB IRET QA QA_ QB QB_ TERM_ORET TIEHI TIELO VDDPE VDDCE
+  VSSE
** pe_spad_1024x16_dpFPIO4: 22 flat devices **
D14 VSSE BWENA NDIO 5.76e-08U 0.96U $name=/D7
D15 VSSE DA NDIO 5.76e-08U 0.96U $name=/D6
D16 VSSE CRENA NDIO 5.76e-08U 0.96U $name=/D5
D17 VSSE QB NDIO 5.76e-08U 0.96U $name=/D19
D18 VSSE QA NDIO 5.76e-08U 0.96U $name=/D18
D19 VSSE CRENB NDIO 5.76e-08U 0.96U $name=/D16
D20 VSSE DB NDIO 5.76e-08U 0.96U $name=/D14
D21 VSSE BWENB NDIO 5.76e-08U 0.96U $name=/D12
M0 QA IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N1/N00
M1 QB IRET VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N0/N00
M10 QA QA_ VSSE VSSE NCH W=3.18U L=0.06U M=1 $name=/gqdrv/N00
M11 VDDPE QA_ QA VDDCE PCH W=4.2U L=0.06U M=1 $name=/gqdrv/P00
M12 QB QB_ VSSE VSSE NCH W=3.18U L=0.06U M=1 $name=/I48/N00
M13 VDDPE QB_ QB VDDCE PCH W=4.2U L=0.06U M=1 $name=/I48/P00
M2 DNA DA VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/gddrv/N00
M3 VDDPE DA DNA VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/gddrv/P00
M4 BWEA BWENA VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gbwendrv/N00
M5 VDDPE BWENA BWEA VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/gbwendrv/P00
M6 DNB DB VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/I51/N00
M7 VDDPE DB DNB VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I51/P00
M8 BWEB BWENB VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I50/N00
M9 VDDPE BWENB BWEB VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I50/P00
.ENDS pe_spad_1024x16_dpFPIO4
****
.SUBCKT pe_spad_1024x16_dpFPFLIO4 BWENA BWENB CRENA CRENAM CRENB CRENBM TIEHI
+  TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPFLIO4: 2 flat devices **
D0 VSSE CRENB NDIO 5.76e-08U 0.96U $name=/D5
D1 VSSE CRENA NDIO 5.76e-08U 0.96U $name=/D29
.ENDS pe_spad_1024x16_dpFPFLIO4
****
.SUBCKT pe_spad_1024x16_dpFPIOX BWEA BWEB DA DB DNA DNB IRET QA QA_ QB QB_
+  TERM_ORET TIEHI TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPIOX: 28 flat devices **
XI0_0 BWEA BWEB TIELO TIELO VSSE TIEHI VSSE TIEHI DA DB DNA DNB IRET QA QA_ QB
+  QB_ TERM_ORET TIEHI TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIO4
XI1_0 TIELO TIELO VSSE TIEHI VSSE TIEHI TIEHI TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPFLIO4
XI2_0 TIELO TIELO VSSE TIEHI VSSE TIEHI TIEHI TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPFLIO4
XI3_0 TIELO TIELO VSSE TIEHI VSSE TIEHI TIEHI TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPFLIO4
.ENDS pe_spad_1024x16_dpFPIOX
****
.SUBCKT pe_spad_1024x16_dpFPIO_ROW_L BWEA_0 BWEA_1 BWEA_2 BWEA_3 BWEA_4 BWEA_5
+  BWEA_6 BWEA_7 BWEB_0 BWEB_1 BWEB_2 BWEB_3 BWEB_4 BWEB_5 BWEB_6 BWEB_7
+  CRENAM DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DB_0 DB_1 DB_2 DB_3 DB_4
+  DB_5 DB_6 DB_7 DNA_0 DNA_1 DNA_2 DNA_3 DNA_4 DNA_5 DNA_6 DNA_7 DNB_0 DNB_1
+  DNB_2 DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 IRET_0 IRET_1 IRET_2 IRET_3 IRET_4
+  IRET_5 IRET_6 IRET_7 QA_0 QA_1 QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA__0 QA__1
+  QA__2 QA__3 QA__4 QA__5 QA__6 QA__7 QB_0 QB_1 QB_2 QB_3 QB_4 QB_5 QB_6 QB_7
+  QB__0 QB__1 QB__2 QB__3 QB__4 QB__5 QB__6 QB__7 TERM_ORET_0 TERM_ORET_1
+  TERM_ORET_2 TERM_ORET_3 TERM_ORET_4 TERM_ORET_5 TERM_ORET_6 TERM_ORET_7
+  TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPIO_ROW_L: 224 flat devices **
XI0_0 BWEA_0 BWEB_0 DA_0 DB_0 DNA_0 DNB_0 IRET_0 QA_0 QA__0 QB_0 QB__0
+  TERM_ORET_0 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI1_0 BWEA_1 BWEB_1 DA_1 DB_1 DNA_1 DNB_1 IRET_1 QA_1 QA__1 QB_1 QB__1
+  TERM_ORET_1 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI2_0 BWEA_2 BWEB_2 DA_2 DB_2 DNA_2 DNB_2 IRET_2 QA_2 QA__2 QB_2 QB__2
+  TERM_ORET_2 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI3_0 BWEA_3 BWEB_3 DA_3 DB_3 DNA_3 DNB_3 IRET_3 QA_3 QA__3 QB_3 QB__3
+  TERM_ORET_3 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI4_0 BWEA_4 BWEB_4 DA_4 DB_4 DNA_4 DNB_4 IRET_4 QA_4 QA__4 QB_4 QB__4
+  TERM_ORET_4 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI5_0 BWEA_5 BWEB_5 DA_5 DB_5 DNA_5 DNB_5 IRET_5 QA_5 QA__5 QB_5 QB__5
+  TERM_ORET_5 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI6_0 BWEA_6 BWEB_6 DA_6 DB_6 DNA_6 DNB_6 IRET_6 QA_6 QA__6 QB_6 QB__6
+  TERM_ORET_6 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI7_0 BWEA_7 BWEB_7 DA_7 DB_7 DNA_7 DNB_7 IRET_7 QA_7 QA__7 QB_7 QB__7
+  TERM_ORET_7 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
.ENDS pe_spad_1024x16_dpFPIO_ROW_L
****
.SUBCKT pe_spad_1024x16_dpFPADDR AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4 AI4N
+  AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10 AI10N AI11 AI11N AI12
+  AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12 BWENA BWENB RDTM RETNM TIELO
+  WBTM VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPADDR: 39 flat devices **
D26 VSSE AI1 NDIO 5.76e-08U 0.96U $name=/D65
D27 VSSE AI0 NDIO 5.76e-08U 0.96U $name=/D60
D28 VSSE AI3 NDIO 5.76e-08U 0.96U $name=/D59
D29 VSSE AI2 NDIO 5.76e-08U 0.96U $name=/D54
D30 VSSE AI4 NDIO 5.76e-08U 0.96U $name=/D53
D31 VSSE AI5 NDIO 5.76e-08U 0.96U $name=/D50
D32 VSSE AI6 NDIO 5.76e-08U 0.96U $name=/D45
D33 VSSE AI7 NDIO 5.76e-08U 0.96U $name=/D44
D34 VSSE AI8 NDIO 5.76e-08U 0.96U $name=/D39
D35 VSSE AI9 NDIO 5.76e-08U 0.96U $name=/D38
D36 VSSE AI10 NDIO 5.76e-08U 0.96U $name=/D33
D37 VSSE AI11 NDIO 5.76e-08U 0.96U $name=/D32
D38 VSSE AI12 NDIO 5.76e-08U 0.96U $name=/D0
M0 AI10N AI10 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/gbsdrv/N00
M1 VDDPE AI10 AI10N VDDCE PCH W=1.27U L=0.06U M=1 $name=/gbsdrv/P00
M10 AI7N AI7 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I7/N00
M11 VDDPE AI7 AI7N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I7/P00
M12 AI6N AI6 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I6/N00
M13 VDDPE AI6 AI6N VDDCE PCH W=1.28U L=0.06U M=1 $name=/I6/P00
M14 AI4N AI4 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I4/N00
M15 VDDPE AI4 AI4N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I4/P00
M16 AI3N AI3 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I3/N00
M17 VDDPE AI3 AI3N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I3/P00
M18 AI2N AI2 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I2/N00
M19 VDDPE AI2 AI2N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I2/P00
M2 AI0N AI0 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/gaydrv/N00
M20 AI12N AI12 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I12/N00
M21 VDDPE AI12 AI12N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I12/P00
M22 AI11N AI11 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I11/N00
M23 VDDPE AI11 AI11N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I11/P00
M24 AI1N AI1 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I1/N00
M25 VDDPE AI1 AI1N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I1/P00
M3 VDDPE AI0 AI0N VDDCE PCH W=1.27U L=0.06U M=1 $name=/gaydrv/P00
M4 AI5N AI5 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/gaxdrv/N00
M5 VDDPE AI5 AI5N VDDCE PCH W=1.27U L=0.06U M=1 $name=/gaxdrv/P00
M6 AI9N AI9 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I9/N00
M7 VDDPE AI9 AI9N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I9/P00
M8 AI8N AI8 VSSE VSSE NCH W=0.63U L=0.06U M=1 $name=/I8/N00
M9 VDDPE AI8 AI8N VDDCE PCH W=1.27U L=0.06U M=1 $name=/I8/P00
.ENDS pe_spad_1024x16_dpFPADDR
****
.SUBCKT pe_spad_1024x16_dpFPADDRX_L AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4
+  AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10N AI11N AI12N AO4 AO5
+  AO6 AO7 AO8 AO9 AO10 AO11 AO12 BWENA BWENB RDTM RETNM TIELO WBTM VDDPE
+  VDDCE VSSE
** pe_spad_1024x16_dpFPADDRX_L: 39 flat devices **
XI0_0 AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4 AI4N AI5 AI5N AI6 AI6N AI7 AI7N
+  AI8 AI8N AI9 AI9N TIELO AI10N TIELO AI11N TIELO AI12N AO4 AO5 AO6 AO7 AO8
+  AO9 AO10 AO11 AO12 BWENA BWENB RDTM RETNM TIELO WBTM VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPADDR
.ENDS pe_spad_1024x16_dpFPADDRX_L
****
.SUBCKT pe_spad_1024x16_dpFPCTRL BWENA BWENB CEI CEN CLK EMA0 EMA1 EMA2 GWEI
+  GWEN RDT RDTM RET RETN RETNM STOV TERM_IRET TERM_ORET TIEHI TIELO WBT WBTM
+  VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPCTRL: 22 flat devices **
D12 VSSE WBT NDIO 5.76e-08U 0.96U $name=/D9
D13 VSSE CEN NDIO 5.76e-08U 0.96U $name=/D5
D14 VSSE RDT NDIO 5.76e-08U 0.96U $name=/D4
D15 VSSE CLK NDIO 5.76e-08U 0.96U $name=/D2
D16 VSSE EMA2 NDIO 5.76e-08U 0.96U $name=/D15
D17 VSSE EMA1 NDIO 5.76e-08U 0.96U $name=/D14
D18 VSSE EMA0 NDIO 5.76e-08U 0.96U $name=/D13
D19 VSSE STOV NDIO 5.76e-08U 0.96U $name=/D12
D20 VSSE RETN NDIO 5.76e-08U 0.96U $name=/D10
D21 VSSE GWEN NDIO 5.76e-08U 0.96U $name=/D0
M0 GWEI GWEN VSSE VSSE NCH W=0.67U L=0.06U M=1 $name=/ggweidrv/N00
M1 VDDPE GWEN GWEI VDDCE PCH W=1.34U L=0.06U M=1 $name=/ggweidrv/P00
M10 NET42 RETNM VSSE VSSE NCH_HVT W=0.37U L=0.06U M=1 $name=/I18/N00
M11 VDDPE RETNM NET42 VDDCE PCH_HVT W=0.85U L=0.06U M=1 $name=/I18/P00
M2 CEI CEN VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/gceidrv/N00
M3 VDDPE CEN CEI VDDCE PCH W=0.4U L=0.06U M=1 $name=/gceidrv/P00
M4 VDDCE RETLAT NET31 VDDCE PCH_HVT W=0.18U L=0.06U M=1 $name=/tplvlshft/P00
M5 VDDCE NET31 RETLAT VDDCE PCH_HVT W=0.18U L=0.06U M=1 $name=/P7/P00
M6 NET31 NET42 VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/tnlvlshft/N00
M7 RETLAT RETNM VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/N7/N00
M8 RET NET31 VSSE VSSE NCH_HVT W=5.48U L=0.06U M=1 $name=/gretdrv/N00
M9 VDDCE NET31 RET VDDCE PCH_HVT W=12.62U L=0.06U M=1 $name=/gretdrv/P00
.ENDS pe_spad_1024x16_dpFPCTRL
****
.SUBCKT pe_spad_1024x16_dpFPCTRLX_L CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN RET
+  RETNM TERM_IRET TERM_ORET TIEHI TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPCTRLX_L: 22 flat devices **
XI0_0 TIELO TIELO CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN VSSE TIELO RET VSSE
+  RETNM TIELO TERM_IRET TERM_ORET TIEHI TIELO VSSE TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPCTRL
.ENDS pe_spad_1024x16_dpFPCTRLX_L
****
.SUBCKT pe_spad_1024x16_dpGFPCTRL_L AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4
+  AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10N AI11N AI12N AO4 AO5
+  AO6 AO7 AO8 AO9 AO10 AO11 AO12 CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN RET
+  RETNM TERM_IRET TERM_ORET TIEHI TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpGFPCTRL_L: 61 flat devices **
XI0_0 AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4 AI4N AI5 AI5N AI6 AI6N AI7 AI7N
+  AI8 AI8N AI9 AI9N AI10N AI11N AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12
+  TIELO TIELO TIELO RETNM TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPADDRX_L
XI1_0 CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN RET RETNM TERM_IRET TERM_ORET TIEHI
+  TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPCTRLX_L
.ENDS pe_spad_1024x16_dpGFPCTRL_L
****
.SUBCKT pe_spad_1024x16_dpFPADDRX_R AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4
+  AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10N AI11N AI12N AO4 AO5
+  AO6 AO7 AO8 AO9 AO10 AO11 AO12 BWENA BWENB RDTM RETNM TIELO WBTM VDDPE
+  VDDCE VSSE
** pe_spad_1024x16_dpFPADDRX_R: 39 flat devices **
XI0_0 AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4 AI4N AI5 AI5N AI6 AI6N AI7 AI7N
+  AI8 AI8N AI9 AI9N TIELO AI10N TIELO AI11N TIELO AI12N AO4 AO5 AO6 AO7 AO8
+  AO9 AO10 AO11 AO12 BWENA BWENB RDTM RETNM TIELO WBTM VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPADDR
.ENDS pe_spad_1024x16_dpFPADDRX_R
****
.SUBCKT pe_spad_1024x16_dpFPCTRLX_R CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN RET
+  RETN TERM_IRET TERM_ORET TIEHI TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPCTRLX_R: 22 flat devices **
XI0_0 TIELO TIELO CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN VSSE TIELO RET RETN
+  RETN TIELO TERM_IRET TERM_ORET TIEHI TIELO VSSE TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPCTRL
.ENDS pe_spad_1024x16_dpFPCTRLX_R
****
.SUBCKT pe_spad_1024x16_dpGFPCTRL_R AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4
+  AI4N AI5 AI5N AI6 AI6N AI7 AI7N AI8 AI8N AI9 AI9N AI10N AI11N AI12N AO4 AO5
+  AO6 AO7 AO8 AO9 AO10 AO11 AO12 CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN RET
+  RETN TERM_IRET TERM_ORET TIEHI TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpGFPCTRL_R: 61 flat devices **
XI0_0 AI0 AI0N AI1 AI1N AI2 AI2N AI3 AI3N AI4 AI4N AI5 AI5N AI6 AI6N AI7 AI7N
+  AI8 AI8N AI9 AI9N AI10N AI11N AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12
+  TIELO TIELO TIELO RETN TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPADDRX_R
XI1_0 CEI CEN CLK EMA0 EMA1 EMA2 GWEI GWEN RET RETN TERM_IRET TERM_ORET TIEHI
+  TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPCTRLX_R
.ENDS pe_spad_1024x16_dpGFPCTRL_R
****
.SUBCKT pe_spad_1024x16_dpFPIO_ROW_R BWEA_0 BWEA_1 BWEA_2 BWEA_3 BWEA_4 BWEA_5
+  BWEA_6 BWEA_7 BWEB_0 BWEB_1 BWEB_2 BWEB_3 BWEB_4 BWEB_5 BWEB_6 BWEB_7
+  CRENAM DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DB_0 DB_1 DB_2 DB_3 DB_4
+  DB_5 DB_6 DB_7 DNA_0 DNA_1 DNA_2 DNA_3 DNA_4 DNA_5 DNA_6 DNA_7 DNB_0 DNB_1
+  DNB_2 DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 IRET_0 IRET_1 IRET_2 IRET_3 IRET_4
+  IRET_5 IRET_6 IRET_7 QA_0 QA_1 QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA__0 QA__1
+  QA__2 QA__3 QA__4 QA__5 QA__6 QA__7 QB_0 QB_1 QB_2 QB_3 QB_4 QB_5 QB_6 QB_7
+  QB__0 QB__1 QB__2 QB__3 QB__4 QB__5 QB__6 QB__7 TERM_ORET_0 TERM_ORET_1
+  TERM_ORET_2 TERM_ORET_3 TERM_ORET_4 TERM_ORET_5 TERM_ORET_6 TERM_ORET_7
+  TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFPIO_ROW_R: 224 flat devices **
XI0_0 BWEA_0 BWEB_0 DA_0 DB_0 DNA_0 DNB_0 IRET_0 QA_0 QA__0 QB_0 QB__0
+  TERM_ORET_0 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI1_0 BWEA_1 BWEB_1 DA_1 DB_1 DNA_1 DNB_1 IRET_1 QA_1 QA__1 QB_1 QB__1
+  TERM_ORET_1 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI2_0 BWEA_2 BWEB_2 DA_2 DB_2 DNA_2 DNB_2 IRET_2 QA_2 QA__2 QB_2 QB__2
+  TERM_ORET_2 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI3_0 BWEA_3 BWEB_3 DA_3 DB_3 DNA_3 DNB_3 IRET_3 QA_3 QA__3 QB_3 QB__3
+  TERM_ORET_3 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI4_0 BWEA_4 BWEB_4 DA_4 DB_4 DNA_4 DNB_4 IRET_4 QA_4 QA__4 QB_4 QB__4
+  TERM_ORET_4 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI5_0 BWEA_5 BWEB_5 DA_5 DB_5 DNA_5 DNB_5 IRET_5 QA_5 QA__5 QB_5 QB__5
+  TERM_ORET_5 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI6_0 BWEA_6 BWEB_6 DA_6 DB_6 DNA_6 DNB_6 IRET_6 QA_6 QA__6 QB_6 QB__6
+  TERM_ORET_6 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
XI7_0 BWEA_7 BWEB_7 DA_7 DB_7 DNA_7 DNB_7 IRET_7 QA_7 QA__7 QB_7 QB__7
+  TERM_ORET_7 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpFPIOX
.ENDS pe_spad_1024x16_dpFPIO_ROW_R
****
.SUBCKT pe_spad_1024x16_dpBOT_ROW AI0N_0 AI0N_1 AI0_0 AI0_1 AI1N_0 AI1N_1
+  AI1_0 AI1_1 AI2N_0 AI2N_1 AI2_0 AI2_1 AI3N_0 AI3N_1 AI3_0 AI3_1 AI4N_0
+  AI4N_1 AI4_0 AI4_1 AI5N_0 AI5N_1 AI5_0 AI5_1 AI6N_0 AI6N_1 AI6_0 AI6_1
+  AI7N_0 AI7N_1 AI7_0 AI7_1 AI8N_0 AI8N_1 AI8_0 AI8_1 AI9N_0 AI9N_1 AI9_0
+  AI9_1 AI10N_0 AI10N_1 AI11N_0 AI11N_1 AI12N_0 AI12N_1 AO4_0 AO4_1 AO5_0
+  AO5_1 AO6_0 AO6_1 AO7_0 AO7_1 AO8_0 AO8_1 AO9_0 AO9_1 AO10_0 AO10_1 AO11_0
+  AO11_1 AO12_0 AO12_1 BWEA_0 BWEA_1 BWEA_2 BWEA_3 BWEA_4 BWEA_5 BWEA_6
+  BWEA_7 BWEA_8 BWEA_9 BWEA_10 BWEA_11 BWEA_12 BWEA_13 BWEA_14 BWEA_15 BWEB_0
+  BWEB_1 BWEB_2 BWEB_3 BWEB_4 BWEB_5 BWEB_6 BWEB_7 BWEB_8 BWEB_9 BWEB_10
+  BWEB_11 BWEB_12 BWEB_13 BWEB_14 BWEB_15 CEI_0 CEI_1 CEN_0 CEN_1 CLK_0 CLK_1
+  CRENAM DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12
+  DA_13 DA_14 DA_15 DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10
+  DB_11 DB_12 DB_13 DB_14 DB_15 DNA_0 DNA_1 DNA_2 DNA_3 DNA_4 DNA_5 DNA_6
+  DNA_7 DNA_8 DNA_9 DNA_10 DNA_11 DNA_12 DNA_13 DNA_14 DNA_15 DNB_0 DNB_1
+  DNB_2 DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 DNB_8 DNB_9 DNB_10 DNB_11 DNB_12 DNB_13
+  DNB_14 DNB_15 EMA0_0 EMA0_1 EMA1_0 EMA1_1 EMA2_0 EMA2_1 GWEI_0 GWEI_1
+  GWEN_0 GWEN_1 IRET_0 IRET_1 IRET_2 IRET_3 IRET_4 IRET_5 IRET_6 IRET_7
+  IRET_8 IRET_9 IRET_10 IRET_11 IRET_12 IRET_13 IRET_14 IRET_15 QA_0 QA_1
+  QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA_8 QA_9 QA_10 QA_11 QA_12 QA_13 QA_14 QA_15
+  QA__0 QA__1 QA__2 QA__3 QA__4 QA__5 QA__6 QA__7 QA__8 QA__9 QA__10 QA__11
+  QA__12 QA__13 QA__14 QA__15 QB_0 QB_1 QB_2 QB_3 QB_4 QB_5 QB_6 QB_7 QB_8
+  QB_9 QB_10 QB_11 QB_12 QB_13 QB_14 QB_15 QB__0 QB__1 QB__2 QB__3 QB__4
+  QB__5 QB__6 QB__7 QB__8 QB__9 QB__10 QB__11 QB__12 QB__13 QB__14 QB__15
+  RETN RET_0 RET_1 TERM_IRET_0 TERM_IRET_1 TERM_ORET_0 TERM_ORET_1
+  TERM_ORET_2 TERM_ORET_3 TERM_ORET_4 TERM_ORET_5 TERM_ORET_6 TERM_ORET_7
+  TERM_ORET_8 TERM_ORET_9 TERM_ORET_10 TERM_ORET_11 TERM_ORET_12 TERM_ORET_13
+  TERM_ORET_14 TERM_ORET_15 TERM_ORET_16 TERM_ORET_17 TIEHI TIELO VDDPE VDDCE
+  VSSE
** pe_spad_1024x16_dpBOT_ROW: 570 flat devices **
XI0_0 BWEA_7 BWEA_6 BWEA_5 BWEA_4 BWEA_3 BWEA_2 BWEA_1 BWEA_0 BWEB_7 BWEB_6
+  BWEB_5 BWEB_4 BWEB_3 BWEB_2 BWEB_1 BWEB_0 CRENAM DA_7 DA_6 DA_5 DA_4 DA_3
+  DA_2 DA_1 DA_0 DB_7 DB_6 DB_5 DB_4 DB_3 DB_2 DB_1 DB_0 DNA_7 DNA_6 DNA_5
+  DNA_4 DNA_3 DNA_2 DNA_1 DNA_0 DNB_7 DNB_6 DNB_5 DNB_4 DNB_3 DNB_2 DNB_1
+  DNB_0 IRET_7 IRET_6 IRET_5 IRET_4 IRET_3 IRET_2 IRET_1 IRET_0 QA_7 QA_6
+  QA_5 QA_4 QA_3 QA_2 QA_1 QA_0 QA__7 QA__6 QA__5 QA__4 QA__3 QA__2 QA__1
+  QA__0 QB_7 QB_6 QB_5 QB_4 QB_3 QB_2 QB_1 QB_0 QB__7 QB__6 QB__5 QB__4 QB__3
+  QB__2 QB__1 QB__0 TERM_ORET_7 TERM_ORET_6 TERM_ORET_5 TERM_ORET_4
+  TERM_ORET_3 TERM_ORET_2 TERM_ORET_1 TERM_ORET_0 TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPIO_ROW_L
XI1_0 AI0_0 AI0N_0 AI1_0 AI1N_0 AI2_0 AI2N_0 AI3_0 AI3N_0 AI4_0 AI4N_0 AI5_0
+  AI5N_0 AI6_0 AI6N_0 AI7_0 AI7N_0 AI8_0 AI8N_0 AI9_0 AI9N_0 AI10N_0 AI11N_0
+  AI12N_0 AO4_0 AO5_0 AO6_0 AO7_0 AO8_0 AO9_0 AO10_0 AO11_0 AO12_0 CEI_0
+  CEN_0 CLK_0 EMA0_0 EMA1_0 EMA2_0 GWEI_0 GWEN_0 RET_0 RETN TERM_IRET_0
+  TERM_ORET_8 CRENAM TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpGFPCTRL_L
XI2_0 AI0_1 AI0N_1 AI1_1 AI1N_1 AI2_1 AI2N_1 AI3_1 AI3N_1 AI4_1 AI4N_1 AI5_1
+  AI5N_1 AI6_1 AI6N_1 AI7_1 AI7N_1 AI8_1 AI8N_1 AI9_1 AI9N_1 AI10N_1 AI11N_1
+  AI12N_1 AO4_1 AO5_1 AO6_1 AO7_1 AO8_1 AO9_1 AO10_1 AO11_1 AO12_1 CEI_1
+  CEN_1 CLK_1 EMA0_1 EMA1_1 EMA2_1 GWEI_1 GWEN_1 RET_1 RETN TERM_IRET_1
+  TERM_ORET_9 TIEHI TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpGFPCTRL_R
XI3_0 BWEA_8 BWEA_9 BWEA_10 BWEA_11 BWEA_12 BWEA_13 BWEA_14 BWEA_15 BWEB_8
+  BWEB_9 BWEB_10 BWEB_11 BWEB_12 BWEB_13 BWEB_14 BWEB_15 TIEHI DA_8 DA_9
+  DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DB_8 DB_9 DB_10 DB_11 DB_12 DB_13 DB_14
+  DB_15 DNA_8 DNA_9 DNA_10 DNA_11 DNA_12 DNA_13 DNA_14 DNA_15 DNB_8 DNB_9
+  DNB_10 DNB_11 DNB_12 DNB_13 DNB_14 DNB_15 IRET_8 IRET_9 IRET_10 IRET_11
+  IRET_12 IRET_13 IRET_14 IRET_15 QA_8 QA_9 QA_10 QA_11 QA_12 QA_13 QA_14
+  QA_15 QA__8 QA__9 QA__10 QA__11 QA__12 QA__13 QA__14 QA__15 QB_8 QB_9 QB_10
+  QB_11 QB_12 QB_13 QB_14 QB_15 QB__8 QB__9 QB__10 QB__11 QB__12 QB__13
+  QB__14 QB__15 TERM_ORET_10 TERM_ORET_11 TERM_ORET_12 TERM_ORET_13
+  TERM_ORET_14 TERM_ORET_15 TERM_ORET_16 TERM_ORET_17 TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpFPIO_ROW_R
.ENDS pe_spad_1024x16_dpBOT_ROW
****
.SUBCKT pe_spad_1024x16_dpIO4 BWEIA BWEIB CRENA CRENAI CRENAJ CRENAM CRENB
+  CRENBI CRENBJ CRENBM DNA DNB FIOBTPA FIOBTPB GDLA GDLAI GDLAI_ GDLAJ GDLAJ_
+  GDLAM GDLAM_ GDLA_ GDLB GDLBI GDLBI_ GDLBJ GDLBJ_ GDLBM GDLBM_ GDLB_ IOBTPA
+  IOBTPB IODLA IODLA_ IODLB IODLB_ IRET ORET QA_ QB_ RDENA RDENB STUB_BLA0
+  STUB_BLA0_ STUB_BLA1 STUB_BLA1_ STUB_BLA2 STUB_BLA2_ STUB_BLA3 STUB_BLA3_
+  STUB_BLB0 STUB_BLB0_ STUB_BLB1 STUB_BLB1_ STUB_BLB2 STUB_BLB2_ STUB_BLB3
+  STUB_BLB3_ TIEHI TIELO WEA WEB WEIA WEIAI WEIAJ WEIAM WEIB WEIBI WEIBJ
+  WEIBM YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B YP_A
+  YP_B YSNA YSNAI YSNAJ YSNAM YSNB YSNBI YSNBJ YSNBM VDDPE VDDCE VSSE
** pe_spad_1024x16_dpIO4: 338 flat devices **
M0 NET1032 RDENA VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/gignor2/N10
M1 NET1032 NET934 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/gignor2/N00
M10 VDDPE NET606 NETP_LATB VDDCE PCH_HVT W=1.2U L=0.06U M=1 $name=/P30/P00
M100 NET901 QIE_NB VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/N14/N00
M101 IODWB_ WEIB NET877 VSSE NCH W=0.46U L=0.06U M=1 $name=/N137/N00
M102 NET883 WEIBN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/N136/N00
M103 IODWB_ WEIB NET883 VSSE NCH W=0.36U L=0.06U M=1 $name=/N135/N00
M104 VSSE NET883 IODLB VSSE NCH W=2U L=0.06U M=1 $name=/N134/N00
M105 IODWB WEIB NET685 VSSE NCH W=0.46U L=0.06U M=1 $name=/N133/N00
M106 NET893 WEIBN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/N132/N00
M107 IODWB WEIB NET893 VSSE NCH W=0.36U L=0.06U M=1 $name=/N131/N00
M108 VSSE NET893 IODLB_ VSSE NCH W=2U L=0.06U M=1 $name=/N130/N00
M109 QB_ NET606 NET901 VSSE NCH W=1.2U L=0.06U M=1 $name=/N13/N00
M11 NETP_LATB QIBLAT QB_ VDDCE PCH_HVT W=1.2U L=0.06U M=1 $name=/tp_latb_fb/P00
M110 VSSE NET907 IODLA_ VSSE NCH W=2U L=0.06U M=1 $name=/N127/N00
M111 IODWA WEIA NET907 VSSE NCH W=0.36U L=0.06U M=1 $name=/N126/N00
M112 NET907 WEIAN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/N125/N00
M113 IODWA WEIA NET913 VSSE NCH W=0.46U L=0.06U M=1 $name=/N124/N00
M114 GDLBM NET_IRSIM1B IODLB VSSE NCH W=1.45U L=0.06U M=1 $name=/N103/N00
M115 GDLBM_ NET_IRSIM1B IODLB_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N102/N00
M116 GDLAM_ NET_IRSIM1A IODLA_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N101/N00
M117 GDLAM NET_IRSIM1A IODLA VSSE NCH W=1.45U L=0.06U M=1 $name=/N100/N00
M118 NET669 NET962 WEIA VSSE NCH W=0.4U L=0.06U M=1 $name=/N1/N00
M119 NET669 NET960 WEIAM VSSE NCH W=0.4U L=0.06U M=1 $name=/N0/N00
M12 VDDPE QIE_NB NETP_LATB VDDCE PCH_HVT W=1.2U L=0.06U M=1 $name=/P28/P00
M120 HNET557 NET938 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/gwennd/N01
M121 NET937 WEA HNET557 VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/gwennd/N00
M122 VDDPE NET938 NET937 VDDCE PCH_HVT W=0.26U L=0.06U M=1 $name=/gwennd/P10
M123 VDDPE WEA NET937 VDDCE PCH_HVT W=0.26U L=0.06U M=1 $name=/gwennd/P00
M124 HNET561 CRENA VSSE VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/gcrend/N01
M125 NET940 CRENAM HNET561 VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/gcrend/N00
M126 VDDPE CRENA NET940 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/gcrend/P10
M127 VDDPE CRENAM NET940 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/gcrend/P00
M128 HNET565 NET974 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/I212/N01
M129 NET1073 WEB HNET565 VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/I212/N00
M13 VDDPE QIE_NA NETP_LATA VDDCE PCH_HVT W=1.2U L=0.06U M=1 $name=/P25/P00
M130 VDDPE NET974 NET1073 VDDCE PCH_HVT W=0.26U L=0.06U M=1 $name=/I212/P10
M131 VDDPE WEB NET1073 VDDCE PCH_HVT W=0.26U L=0.06U M=1 $name=/I212/P00
M132 HNET569 CRENB VSSE VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/I158/N01
M133 NET946 CRENBM HNET569 VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/I158/N00
M134 VDDPE CRENB NET946 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/I158/P10
M135 VDDPE CRENBM NET946 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/I158/P00
M136 NET938 NET950 VSSE VSSE NCH_HVT W=0.16U L=0.06U M=1 $name=/gweninv1/N00
M137 VDDPE NET950 NET938 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/gweninv1/P00
M138 NET950 BWEIA VSSE VSSE NCH_HVT W=0.16U L=0.06U M=1 $name=/gweninv/N00
M139 VDDPE BWEIA NET950 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/gweninv/P00
M14 YSNAM NET962 NET809 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpyspass/P00
M140 NET952 NET953 VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/gdinv3/N00
M141 VDDPE NET953 NET952 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/gdinv3/P00
M142 NET953 NET955 VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/gdinv2/N00
M143 VDDPE NET955 NET953 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/gdinv2/P00
M144 NET955 NET958 VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/gdinv1/N00
M145 VDDPE NET958 NET955 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/gdinv1/P00
M146 NET958 DNA VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/gdinv/N00
M147 VDDPE DNA NET958 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/gdinv/P00
M148 NET960 NET962 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/gcreinv2/N00
M149 VDDPE NET962 NET960 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/gcreinv2/P00
M15 YP_A IOCLKA0 NET812 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tpyppg/P00
M150 NET962 NET940 VSSE VSSE NCH_HVT W=0.6U L=0.06U M=1 $name=/gcreinv1/N00
M151 VDDPE NET940 NET962 VDDCE PCH_HVT W=0.92U L=0.06U M=1 $name=/gcreinv1/P00
M152 NET964 DNB VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/I245/N00
M153 VDDPE DNB NET964 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/I245/P00
M154 NET969 NET964 VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/I244/N00
M155 VDDPE NET964 NET969 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/I244/P00
M156 NET968 NET969 VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/I243/N00
M157 VDDPE NET969 NET968 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/I243/P00
M158 NET970 NET968 VSSE VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/I242/N00
M159 VDDPE NET968 NET970 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/I242/P00
M16 NET985 IOCLKA0 WIA VDDCE PCH W=0.4U L=0.06U M=1 $name=/tpwpass/P00
M160 NET975 BWEIB VSSE VSSE NCH_HVT W=0.16U L=0.06U M=1 $name=/I214/N00
M161 VDDPE BWEIB NET975 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/I214/P00
M162 NET974 NET975 VSSE VSSE NCH_HVT W=0.16U L=0.06U M=1 $name=/I213/N00
M163 VDDPE NET975 NET974 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/I213/P00
M164 NET867 NET946 VSSE VSSE NCH_HVT W=0.6U L=0.06U M=1 $name=/I159/N00
M165 VDDPE NET946 NET867 VDDCE PCH_HVT W=0.92U L=0.06U M=1 $name=/I159/P00
M166 NET771 NET867 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/I149/N00
M167 VDDPE NET867 NET771 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/I149/P00
M168 HNET608 NET1012 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gypfb/NI00
M169 NET812 IOCLKA0 HNET608 VSSE NCH W=0.15U L=0.06U M=1 $name=/gypfb/NE00
M17 QA_ NET597 VDDPE VDDCE PCH W=0.6U L=0.06U M=1 $name=/tpqbk/P00
M170 HNET603 DIOCLKNA NET812 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gypfb/PE00
M171 VDDPE NET1012 HNET603 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gypfb/PI00
M172 HNET614 WELOUTA VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gwenlatfb/NI00
M173 NET985 IOCLKA0 HNET614 VSSE NCH W=0.15U L=0.06U M=1 $name=/gwenlatfb/NE00
M174 HNET609 DIOCLKNA NET985 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gwenlatfb/PE00
M175 VDDPE WELOUTA HNET609 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gwenlatfb/PI00
M176 HNET620 DLATNA VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NI00
M177 NET832 IOCLKA0 HNET620 VSSE NCH W=0.15U L=0.06U M=1 $name=/gdlatfb/NE00
M178 HNET615 DIOCLKNA NET832 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PE00
M179 VDDPE DLATNA HNET615 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gdlatfb/PI00
M18 VDDPE IOCLKNA NET710 VDDCE PCH W=2.15U L=0.06U M=1 $name=/tpqb/P00
M180 HNET626 NET1050 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I87/NI00
M181 NET860 IOCLKB0 HNET626 VSSE NCH W=0.15U L=0.06U M=1 $name=/I87/NE00
M182 HNET621 DIOCLKNB NET860 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I87/PE00
M183 VDDPE NET1050 HNET621 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I87/PI00
M184 HNET632 DLATNB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I108/NI00
M185 NET997 IOCLKB0 HNET632 VSSE NCH W=0.15U L=0.06U M=1 $name=/I108/NE00
M186 HNET627 DIOCLKNB NET997 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I108/PE00
M187 VDDPE DLATNB HNET627 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I108/PI00
M188 HNET638 WELOUTB VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I107/NI00
M189 NET844 IOCLKB0 HNET638 VSSE NCH W=0.15U L=0.06U M=1 $name=/I107/NE00
M19 NET649 WEIAN IODWA_ VDDCE PCH W=0.56U L=0.06U M=1 $name=/tpgdlppg/P00
M190 HNET633 DIOCLKNB NET844 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I107/PE00
M191 VDDPE WELOUTB HNET633 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I107/PI00
M192 YSELA YSNA VSSE VSSE NCH W=0.29U L=0.06U M=1 $name=/gysna/N00
M193 VDDPE YSNA YSELA VDDCE PCH W=0.57U L=0.06U M=1 $name=/gysna/P00
M194 NET_IRSIM1A NET_IRSIM0A VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/gyselfr/N00
M195 VDDPE NET_IRSIM0A NET_IRSIM1A VDDCE PCH W=0.78U L=0.06U M=1 $name=/gyselfr/P00
M196 NET_IRSIM11A NET_IRSIM00A VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/gysel/N00
M197 VDDPE NET_IRSIM00A NET_IRSIM11A VDDCE PCH W=0.78U L=0.06U M=1 $name=/gysel/P00
M198 NET1010 NET809 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/gypinv1/N00
M199 VDDPE NET809 NET1010 VDDCE PCH W=0.35U L=0.06U M=1 $name=/gypinv1/P00
M2 VDDPE RDENA HNET209 VDDCE PCH W=0.54U L=0.06U M=1 $name=/gignor2/P01
M20 IODLA NET_IRSIM00A GDLA VDDCE PCH W=1.56U L=0.06U M=1 $name=/tpgdlpg/P00
M200 NET1012 NET812 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gypinv/N00
M201 VDDPE NET812 NET1012 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gypinv/P00
M202 YSNA NET812 VSSE VSSE NCH W=0.68U L=0.06U M=1 $name=/gyp/N00
M203 VDDPE NET812 YSNA VDDCE PCH W=1.6U L=0.06U M=1 $name=/gyp/P00
M204 WELOUTA NET985 VSSE VSSE NCH W=0.48U L=0.06U M=1 $name=/gwenlat/N00
M205 VDDPE NET985 WELOUTA VDDCE PCH W=0.69U L=0.06U M=1 $name=/gwenlat/P00
M206 WIA NET937 VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/gweninv2/N00
M207 VDDPE NET937 WIA VDDCE PCH W=0.6U L=0.06U M=1 $name=/gweninv2/P00
M208 WEIA WELOUTA VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gwendrv/N00
M209 VDDPE WELOUTA WEIA VDDCE PCH W=1.2U L=0.06U M=1 $name=/gwendrv/P00
M21 NET836 WEIAN IODWA_ VDDCE PCH W=0.67U L=0.06U M=1 $name=/tpgdlnpg/P00
M210 QIALAT QA_ VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/gqbinv/N00
M211 VDDPE QA_ QIALAT VDDCE PCH W=0.44U L=0.06U M=1 $name=/gqbinv/P00
M212 NET597 ORET VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/giooret/N00
M213 VDDPE ORET NET597 VDDCE PCH W=0.3U L=0.06U M=1 $name=/giooret/P00
M214 NET1026 IODLA_ VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/giodl/N00
M215 VDDPE IODLA_ NET1026 VDDCE PCH W=0.52U L=0.06U M=1 $name=/giodl/P00
M216 QIE_NA IOCLKNA VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/giocinv1/N00
M217 VDDPE IOCLKNA QIE_NA VDDCE PCH W=0.52U L=0.06U M=1 $name=/giocinv1/P00
M218 NET1108 IOBTPA VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/giobtp/N00
M219 VDDPE IOBTPA NET1108 VDDCE PCH W=0.4U L=0.06U M=1 $name=/giobtp/P00
M22 IODLA NET649 VDDPE VDDCE PCH W=2.8U L=0.06U M=1 $name=/tpgdldrv/P00
M220 DIOCLKNA IOCLKA0 VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/ginvpass1/N00
M221 VDDPE IOCLKA0 DIOCLKNA VDDCE PCH W=1.2U L=0.06U M=1 $name=/ginvpass1/P00
M222 IOCLKNA NET1032 VSSE VSSE NCH W=0.39U L=0.06U M=1 $name=/giginv1/N00
M223 VDDPE NET1032 IOCLKNA VDDCE PCH W=0.52U L=0.06U M=1 $name=/giginv1/P00
M224 WEIAN WEIA VSSE VSSE NCH W=0.27U L=0.06U M=1 $name=/ggdron/N00
M225 VDDPE WEIA WEIAN VDDCE PCH W=0.33U L=0.06U M=1 $name=/ggdron/P00
M226 IODWA_ NET1039 VSSE VSSE NCH W=0.66U L=0.06U M=1 $name=/ggdlpredrv/N00
M227 VDDPE NET1039 IODWA_ VDDCE PCH W=1U L=0.06U M=1 $name=/ggdlpredrv/P00
M228 NET1039 DLATNA VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/ggdlinv/N00
M229 VDDPE DLATNA NET1039 VDDCE PCH W=0.22U L=0.06U M=1 $name=/ggdlinv/P00
M23 NET832 IOCLKA0 DIA VDDCE PCH W=0.6U L=0.06U M=1 $name=/tpdpass/P00
M230 NET933 FIOBTPA VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/gfiobtp/N00
M231 VDDPE FIOBTPA NET933 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gfiobtp/P00
M232 DLATNA NET832 VSSE VSSE NCH W=0.43U L=0.06U M=1 $name=/gdlat/N00
M233 VDDPE NET832 DLATNA VDDCE PCH W=0.64U L=0.06U M=1 $name=/gdlat/P00
M234 DIA NET952 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/gdinv4/N00
M235 VDDPE NET952 DIA VDDCE PCH W=0.8U L=0.06U M=1 $name=/gdinv4/P00
M236 NET1048 NET869 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I86/N00
M237 VDDPE NET869 NET1048 VDDCE PCH W=0.35U L=0.06U M=1 $name=/I86/P00
M238 NET1050 NET860 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I85/N00
M239 VDDPE NET860 NET1050 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I85/P00
M24 VDDPE WEIA NET649 VDDCE PCH W=0.48U L=0.06U M=1 $name=/tgdlpukp/P00
M240 WEIB WELOUTB VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I83/N00
M241 VDDPE WELOUTB WEIB VDDCE PCH W=1.2U L=0.06U M=1 $name=/I83/P00
M242 QIE_NB IOCLKNB VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/I43/N00
M243 VDDPE IOCLKNB QIE_NB VDDCE PCH W=0.52U L=0.06U M=1 $name=/I43/P00
M244 NET606 IODLB_ VSSE VSSE NCH W=0.36U L=0.06U M=1 $name=/I42/N00
M245 VDDPE IODLB_ NET606 VDDCE PCH W=0.52U L=0.06U M=1 $name=/I42/P00
M246 QIBLAT QB_ VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/I40/N00
M247 VDDPE QB_ QIBLAT VDDCE PCH W=0.44U L=0.06U M=1 $name=/I40/P00
M248 IODWA DLATNA VSSE VSSE NCH W=0.66U L=0.06U M=1 $name=/I37/N00
M249 VDDPE DLATNA IODWA VDDCE PCH W=1U L=0.06U M=1 $name=/I37/P00
M25 VDDPE PRENA GDLA VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdlpchg/P00
M250 DIOCLKNB IOCLKB0 VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/I33/N00
M251 VDDPE IOCLKB0 DIOCLKNB VDDCE PCH W=1.2U L=0.06U M=1 $name=/I33/P00
M252 YSELB YSNB VSSE VSSE NCH W=0.29U L=0.06U M=1 $name=/I246/N00
M253 VDDPE YSNB YSELB VDDCE PCH W=0.57U L=0.06U M=1 $name=/I246/P00
M254 YSNB NET860 VSSE VSSE NCH W=0.68U L=0.06U M=1 $name=/I239/N00
M255 VDDPE NET860 YSNB VDDCE PCH W=1.6U L=0.06U M=1 $name=/I239/P00
M256 IOCLKNB NET1068 VSSE VSSE NCH W=0.39U L=0.06U M=1 $name=/I227/N00
M257 VDDPE NET1068 IOCLKNB VDDCE PCH W=0.52U L=0.06U M=1 $name=/I227/P00
M258 WIB NET1073 VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/I211/N00
M259 VDDPE NET1073 WIB VDDCE PCH W=0.6U L=0.06U M=1 $name=/I211/P00
M26 NET656 GDLA_ GDLA VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlkp/P00
M260 WEIBN WEIB VSSE VSSE NCH W=0.27U L=0.06U M=1 $name=/I209/N00
M261 VDDPE WEIB WEIBN VDDCE PCH W=0.33U L=0.06U M=1 $name=/I209/P00
M262 NET1076 FIOBTPB VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I185/N00
M263 VDDPE FIOBTPB NET1076 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I185/P00
M264 DIB NET970 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I152/N00
M265 VDDPE NET970 DIB VDDCE PCH W=0.8U L=0.06U M=1 $name=/I152/P00
M266 NET_IRSIM11B NET_IRSIM00B VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/I151/N00
M267 VDDPE NET_IRSIM00B NET_IRSIM11B VDDCE PCH W=0.78U L=0.06U M=1 $name=/I151/P00
M268 NET_IRSIM1B NET_IRSIM0B VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/I150/N00
M269 VDDPE NET_IRSIM0B NET_IRSIM1B VDDCE PCH W=0.78U L=0.06U M=1 $name=/I150/P00
M27 GDLA PRENA GDLA_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdleq/P00
M270 IODWB DLATNB VSSE VSSE NCH W=0.66U L=0.06U M=1 $name=/I123/N00
M271 VDDPE DLATNB IODWB VDDCE PCH W=1U L=0.06U M=1 $name=/I123/P00
M272 NET1089 DLATNB VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I119/N00
M273 VDDPE DLATNB NET1089 VDDCE PCH W=0.22U L=0.06U M=1 $name=/I119/P00
M274 IODWB_ NET1089 VSSE VSSE NCH W=0.66U L=0.06U M=1 $name=/I118/N00
M275 VDDPE NET1089 IODWB_ VDDCE PCH W=1U L=0.06U M=1 $name=/I118/P00
M276 WELOUTB NET844 VSSE VSSE NCH W=0.48U L=0.06U M=1 $name=/I106/N00
M277 VDDPE NET844 WELOUTB VDDCE PCH W=0.69U L=0.06U M=1 $name=/I106/P00
M278 DLATNB NET997 VSSE VSSE NCH W=0.43U L=0.06U M=1 $name=/I105/N00
M279 VDDPE NET997 DLATNB VDDCE PCH W=0.64U L=0.06U M=1 $name=/I105/P00
M28 NET662 GDLB GDLB_ VDDCE PCH W=1U L=0.06U M=1 $name=/P98/P00
M280 NET01099 IOBTPB VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I103/N00
M281 VDDPE IOBTPB NET01099 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I103/P00
M282 HNET731 IOBTPA VSSE VSSE NCH W=0.33U L=0.06U M=1 $name=/I0/N01
M283 NET934 NET933 HNET731 VSSE NCH W=0.33U L=0.06U M=1 $name=/I0/N00
M284 VDDPE IOBTPA NET934 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I0/P10
M285 VDDPE NET933 NET934 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I0/P00
M286 HNET735 IOBTPB VSSE VSSE NCH W=0.33U L=0.06U M=1 $name=/I3/N01
M287 NET1115 NET1076 HNET735 VSSE NCH W=0.33U L=0.06U M=1 $name=/I3/N00
M288 VDDPE IOBTPB NET1115 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I3/P10
M289 VDDPE NET1076 NET1115 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I3/P00
M29 NET662 GDLB_ GDLB VDDCE PCH W=1U L=0.06U M=1 $name=/P97/P00
M290 HNET739 NET01099 VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/I2/N01
M291 IOCLKB0 IOCLKNB HNET739 VSSE NCH W=1.05U L=0.06U M=1 $name=/I2/N00
M292 VDDPE NET01099 IOCLKB0 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I2/P10
M293 VDDPE IOCLKNB IOCLKB0 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I2/P00
M294 HNET743 NET1108 VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/I1/N01
M295 IOCLKA0 IOCLKNA HNET743 VSSE NCH W=1.05U L=0.06U M=1 $name=/I1/N00
M296 VDDPE NET1108 IOCLKA0 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I1/P10
M297 VDDPE IOCLKNA IOCLKA0 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I1/P00
M298 HNET747 NET962 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselnd/N01
M299 NET_IRSIM00A YSELA HNET747 VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselnd/N00
M3 HNET209 NET934 NET1032 VDDCE PCH W=0.54U L=0.06U M=1 $name=/gignor2/P00
M30 VDDPE NET1128 NET662 VDDCE PCH W=1U L=0.06U M=1 $name=/P96/P00
M300 VDDPE NET962 NET_IRSIM00A VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselnd/P10
M301 VDDPE YSELA NET_IRSIM00A VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselnd/P00
M302 HNET751 NET960 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/N01
M303 NET_IRSIM0A YSELA HNET751 VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/N00
M304 VDDPE NET960 NET_IRSIM0A VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/P10
M305 VDDPE YSELA NET_IRSIM0A VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/P00
M306 HNET755 NET1010 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gprennd1/N01
M307 NET1103 NET669 HNET755 VSSE NCH W=1U L=0.06U M=1 $name=/gprennd1/N00
M308 VDDPE NET1010 NET1103 VDDCE PCH W=1U L=0.06U M=1 $name=/gprennd1/P10
M309 VDDPE NET669 NET1103 VDDCE PCH W=1U L=0.06U M=1 $name=/gprennd1/P00
M31 VDDPE NET669 NET656 VDDCE PCH W=1U L=0.06U M=1 $name=/P95/P00
M310 HNET759 NET1107 VSSE VSSE NCH W=1.54U L=0.06U M=1 $name=/gprennd/N01
M311 PRENA NET1103 HNET759 VSSE NCH W=1.54U L=0.06U M=1 $name=/gprennd/N00
M312 VDDPE NET1107 PRENA VDDCE PCH W=1.54U L=0.06U M=1 $name=/gprennd/P10
M313 VDDPE NET1103 PRENA VDDCE PCH W=1.54U L=0.06U M=1 $name=/gprennd/P00
M314 HNET763 IOCLKA0 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/gfiobtpnd/N01
M315 NET1107 NET933 HNET763 VSSE NCH W=0.7U L=0.06U M=1 $name=/gfiobtpnd/N00
M316 VDDPE IOCLKA0 NET1107 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gfiobtpnd/P10
M317 VDDPE NET933 NET1107 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gfiobtpnd/P00
M318 HNET767 IOCLKB0 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/I181/N01
M319 NET01126 NET1076 HNET767 VSSE NCH W=0.7U L=0.06U M=1 $name=/I181/N00
M32 VDDPE WEIB NET877 VDDCE PCH W=0.48U L=0.06U M=1 $name=/P92/P00
M320 VDDPE IOCLKB0 NET01126 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I181/P10
M321 VDDPE NET1076 NET01126 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I181/P00
M322 HNET771 NET771 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I148/N01
M323 NET_IRSIM0B YSELB HNET771 VSSE NCH W=0.8U L=0.06U M=1 $name=/I148/N00
M324 VDDPE NET771 NET_IRSIM0B VDDCE PCH W=0.8U L=0.06U M=1 $name=/I148/P10
M325 VDDPE YSELB NET_IRSIM0B VDDCE PCH W=0.8U L=0.06U M=1 $name=/I148/P00
M326 HNET775 NET867 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I147/N01
M327 NET_IRSIM00B YSELB HNET775 VSSE NCH W=0.8U L=0.06U M=1 $name=/I147/N00
M328 VDDPE NET867 NET_IRSIM00B VDDCE PCH W=0.8U L=0.06U M=1 $name=/I147/P10
M329 VDDPE YSELB NET_IRSIM00B VDDCE PCH W=0.8U L=0.06U M=1 $name=/I147/P00
M33 NET877 WEIBN IODWB_ VDDCE PCH W=0.56U L=0.06U M=1 $name=/P91/P00
M330 HNET779 NET01126 VSSE VSSE NCH W=1.54U L=0.06U M=1 $name=/I139/N01
M331 PRENB NET1127 HNET779 VSSE NCH W=1.54U L=0.06U M=1 $name=/I139/N00
M332 VDDPE NET01126 PRENB VDDCE PCH W=1.54U L=0.06U M=1 $name=/I139/P10
M333 VDDPE NET1127 PRENB VDDCE PCH W=1.54U L=0.06U M=1 $name=/I139/P00
M334 HNET783 NET1048 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I100/N01
M335 NET1127 NET1128 HNET783 VSSE NCH W=1U L=0.06U M=1 $name=/I100/N00
M336 VDDPE NET1048 NET1127 VDDCE PCH W=1U L=0.06U M=1 $name=/I100/P10
M337 VDDPE NET1128 NET1127 VDDCE PCH W=1U L=0.06U M=1 $name=/I100/P00
M34 NET883 WEIBN IODWB_ VDDCE PCH W=0.67U L=0.06U M=1 $name=/P90/P00
M35 IODLB NET877 VDDPE VDDCE PCH W=2.8U L=0.06U M=1 $name=/P89/P00
M36 VDDPE WEIB NET685 VDDCE PCH W=0.48U L=0.06U M=1 $name=/P88/P00
M37 NET685 WEIBN IODWB VDDCE PCH W=0.56U L=0.06U M=1 $name=/P87/P00
M38 NET893 WEIBN IODWB VDDCE PCH W=0.67U L=0.06U M=1 $name=/P86/P00
M39 IODLB_ NET685 VDDPE VDDCE PCH W=2.8U L=0.06U M=1 $name=/P85/P00
M4 NET1068 RDENB VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I238/N10
M40 NET907 WEIAN IODWA VDDCE PCH W=0.67U L=0.06U M=1 $name=/P82/P00
M41 NET913 WEIAN IODWA VDDCE PCH W=0.56U L=0.06U M=1 $name=/P81/P00
M42 VDDPE WEIA NET913 VDDCE PCH W=0.48U L=0.06U M=1 $name=/P80/P00
M43 NET656 GDLA GDLA_ VDDCE PCH W=1U L=0.06U M=1 $name=/P77/P00
M44 NET710 IODLA QA_ VDDCE PCH W=2.15U L=0.06U M=1 $name=/P7/P00
M45 WEIBM NET867 NET1128 VDDCE PCH W=0.4U L=0.06U M=1 $name=/P6/P00
M46 IODLB NET_IRSIM0B GDLBM VDDCE PCH W=1.56U L=0.06U M=1 $name=/P56/P00
M47 IODLB_ NET_IRSIM0B GDLBM_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P55/P00
M48 IODLA_ NET_IRSIM0A GDLAM_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P54/P00
M49 IODLA NET_IRSIM0A GDLAM VDDCE PCH W=1.56U L=0.06U M=1 $name=/P53/P00
M5 NET1068 NET1115 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I238/N00
M50 WEIB NET771 NET1128 VDDCE PCH W=0.4U L=0.06U M=1 $name=/P5/P00
M51 IODLA_ NET913 VDDPE VDDCE PCH W=2.8U L=0.06U M=1 $name=/P43/P00
M52 NET844 IOCLKB0 WIB VDDCE PCH W=0.4U L=0.06U M=1 $name=/P41/P00
M53 NET997 IOCLKB0 DIB VDDCE PCH W=0.6U L=0.06U M=1 $name=/P40/P00
M54 WEIA NET960 NET669 VDDCE PCH W=0.4U L=0.06U M=1 $name=/P4/P00
M55 YP_B IOCLKB0 NET860 VDDCE PCH W=0.5U L=0.06U M=1 $name=/P38/P00
M56 IODLB NET_IRSIM00B GDLB VDDCE PCH W=1.56U L=0.06U M=1 $name=/P3/P00
M57 QB_ NET597 VDDPE VDDCE PCH W=0.6U L=0.06U M=1 $name=/P27/P00
M58 IODLA_ NET_IRSIM00A GDLA_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P22/P00
M59 VDDPE PRENA GDLA_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/P2/P00
M6 VDDPE RDENB HNET214 VDDCE PCH W=0.54U L=0.06U M=1 $name=/I238/P01
M60 VDDPE PRENB GDLB_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/P19/P00
M61 GDLB PRENB GDLB_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/P17/P00
M62 VDDPE PRENB GDLB VDDCE PCH W=1.5U L=0.06U M=1 $name=/P16/P00
M63 VDDPE IOCLKNB NET767 VDDCE PCH W=2.15U L=0.06U M=1 $name=/P15/P00
M64 NET767 IODLB QB_ VDDCE PCH W=2.15U L=0.06U M=1 $name=/P14/P00
M65 YSNBM NET867 NET869 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P102/P00
M66 YSNB NET771 NET869 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P101/P00
M67 YSNA NET960 NET809 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P100/P00
M68 IODLB_ NET_IRSIM00B GDLB_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P1/P00
M69 WEIAM NET962 NET669 VDDCE PCH W=0.4U L=0.06U M=1 $name=/P0/P00
M7 HNET214 NET1115 NET1068 VDDCE PCH W=0.54U L=0.06U M=1 $name=/I238/P00
M70 NET805 NET597 VSSE VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/tnqbfb/N00
M71 QB_ QIBLAT NETN_LATB VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/tn_latb_fb/N00
M72 NET791 NET597 VSSE VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/N43/N00
M73 NETN_LATB IOCLKNB NET791 VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/N42/N00
M74 NETN_LATB IODLB NET791 VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/N41/N00
M75 QA_ QIALAT NETN_LATA VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/tn_lata_fb/N00
M76 NETN_LATA IODLA NET805 VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/N39/N00
M77 NETN_LATA IOCLKNA NET805 VSSE NCH_HVT W=1.08U L=0.06U M=1 $name=/N37/N00
M78 NET809 NET960 YSNAM VSSE NCH W=0.15U L=0.06U M=1 $name=/tnyspass/N00
M79 NET812 DIOCLKNA YP_A VSSE NCH W=0.5U L=0.06U M=1 $name=/tnyppg/N00
M8 VDDPE NET1026 NETP_LATA VDDCE PCH_HVT W=1.2U L=0.06U M=1 $name=/tpqbfb/P00
M80 WIA DIOCLKNA NET985 VSSE NCH W=0.4U L=0.06U M=1 $name=/tnwpass/N00
M81 NET862 QIE_NA VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/tnqb/N00
M82 IODWA_ WEIA NET649 VSSE NCH W=0.46U L=0.06U M=1 $name=/tngdlppg/N00
M83 GDLA NET_IRSIM11A IODLA VSSE NCH W=1.45U L=0.06U M=1 $name=/tngdlpg/N00
M84 IODWA_ WEIA NET836 VSSE NCH W=0.36U L=0.06U M=1 $name=/tngdlnpg/N00
M85 VSSE NET836 IODLA VSSE NCH W=2U L=0.06U M=1 $name=/tngdldrv/N00
M86 DIA DIOCLKNA NET832 VSSE NCH W=0.4U L=0.06U M=1 $name=/tndpass/N00
M87 NET836 WEIAN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/tgdlpdkp/N00
M88 GDLB NET_IRSIM11B IODLB VSSE NCH W=1.45U L=0.06U M=1 $name=/N7/N00
M89 GDLB_ NET_IRSIM11B IODLB_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N6/N00
M9 NETP_LATA QIALAT QA_ VDDCE PCH_HVT W=1.2U L=0.06U M=1 $name=/tp_lata_fb/P00
M90 WIB DIOCLKNB NET844 VSSE NCH W=0.4U L=0.06U M=1 $name=/N32/N00
M91 DIB DIOCLKNB NET997 VSSE NCH W=0.4U L=0.06U M=1 $name=/N30/N00
M92 NET1128 NET771 WEIBM VSSE NCH W=0.4U L=0.06U M=1 $name=/N3/N00
M93 GDLA_ NET_IRSIM11A IODLA_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N23/N00
M94 NET1128 NET867 WEIB VSSE NCH W=0.4U L=0.06U M=1 $name=/N2/N00
M95 NET860 DIOCLKNB YP_B VSSE NCH W=0.5U L=0.06U M=1 $name=/N19/N00
M96 QA_ NET1026 NET862 VSSE NCH W=1.2U L=0.06U M=1 $name=/N15/N00
M97 NET869 NET771 YSNBM VSSE NCH W=0.15U L=0.06U M=1 $name=/N143/N00
M98 NET869 NET867 YSNB VSSE NCH W=0.15U L=0.06U M=1 $name=/N142/N00
M99 NET809 NET962 YSNA VSSE NCH W=0.15U L=0.06U M=1 $name=/N141/N00
.ENDS pe_spad_1024x16_dpIO4
****
.SUBCKT pe_spad_1024x16_dpFLIO4 CRENA CRENAI CRENAJ CRENAM CRENB CRENBI CRENBJ
+  CRENBM FIOBTPA FIOBTPB GDLA GDLAI GDLAI_ GDLAJ GDLAJ_ GDLAM GDLAM_ GDLA_
+  GDLB GDLBI GDLBI_ GDLBJ GDLBJ_ GDLBM GDLBM_ GDLB_ IOBTPA IOBTPB IODLA
+  IODLA_ IODLB IODLB_ IRET ORET STUB_BLA0 STUB_BLA0_ STUB_BLA1 STUB_BLA1_
+  STUB_BLA2 STUB_BLA2_ STUB_BLA3 STUB_BLA3_ STUB_BLB0 STUB_BLB0_ STUB_BLB1
+  STUB_BLB1_ STUB_BLB2 STUB_BLB2_ STUB_BLB3 STUB_BLB3_ TIEHI TIELO WEA WEB
+  WEIA WEIAI WEIAJ WEIAM WEIB WEIBI WEIBJ WEIBM YP1_0_A YP1_0_B YP1_1_A
+  YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B YP_A YP_B YSNA YSNAI YSNAJ YSNAM
+  YSNB YSNBI YSNBJ YSNBM VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFLIO4: 172 flat devices **
M0 YSNAM NET612 NET542 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpyspass/P00
M1 YP_A NET667 NET545 VDDCE PCH W=0.5U L=0.06U M=1 $name=/tpyppg/P00
M10 VDDPE NET480 NET467 VDDCE PCH W=1U L=0.06U M=1 $name=/P95/P00
M100 NET644 NET569 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I85/N00
M101 VDDPE NET569 NET644 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I85/P00
M102 YSELB YSNB VSSE VSSE NCH W=0.29U L=0.06U M=1 $name=/I239/N00
M103 VDDPE YSNB YSELB VDDCE PCH W=0.57U L=0.06U M=1 $name=/I239/P00
M104 YSNB NET569 VSSE VSSE NCH W=0.34U L=0.06U M=1 $name=/I238/N00
M105 VDDPE NET569 YSNB VDDCE PCH W=0.8U L=0.06U M=1 $name=/I238/P00
M106 YSNA NET545 VSSE VSSE NCH W=0.34U L=0.06U M=1 $name=/I237/N00
M107 VDDPE NET545 YSNA VDDCE PCH W=0.8U L=0.06U M=1 $name=/I237/P00
M108 NET652 FIOBTPB VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I185/N00
M109 VDDPE FIOBTPB NET652 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I185/P00
M11 NET467 GDLA GDLA_ VDDCE PCH W=1U L=0.06U M=1 $name=/P77/P00
M110 NET555 NET537 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/I151/N00
M111 VDDPE NET537 NET555 VDDCE PCH W=0.78U L=0.06U M=1 $name=/I151/P00
M112 NET582 NET492 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/I150/N00
M113 VDDPE NET492 NET582 VDDCE PCH W=0.78U L=0.06U M=1 $name=/I150/P00
M114 NET668 IOBTPA VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/giobtp/N00
M115 VDDPE IOBTPA NET668 VDDCE PCH W=0.4U L=0.06U M=1 $name=/giobtp/P00
M116 HNET362 IOBTPA VSSE VSSE NCH W=0.33U L=0.06U M=1 $name=/I0/N01
M117 NET661 NET660 HNET362 VSSE NCH W=0.33U L=0.06U M=1 $name=/I0/N00
M118 VDDPE IOBTPA NET661 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I0/P10
M119 VDDPE NET660 NET661 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I0/P00
M12 WEIBM NET573 NET701 VDDCE PCH W=0.4U L=0.06U M=1 $name=/P6/P00
M120 HNET366 IOBTPB VSSE VSSE NCH W=0.33U L=0.06U M=1 $name=/I2/N01
M121 NET664 NET652 HNET366 VSSE NCH W=0.33U L=0.06U M=1 $name=/I2/N00
M122 VDDPE IOBTPB NET664 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I2/P10
M123 VDDPE NET652 NET664 VDDCE PCH W=0.33U L=0.06U M=1 $name=/I2/P00
M124 HNET370 NET668 VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/I1/N01
M125 NET667 IOCLKNA HNET370 VSSE NCH W=1.05U L=0.06U M=1 $name=/I1/N00
M126 VDDPE NET668 NET667 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I1/P10
M127 VDDPE IOCLKNA NET667 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I1/P00
M128 HNET374 NET667 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/gfiobtpnd/N01
M129 NET689 NET660 HNET374 VSSE NCH W=0.7U L=0.06U M=1 $name=/gfiobtpnd/N00
M13 IODLB NET492 GDLBM VDDCE PCH W=1.56U L=0.06U M=1 $name=/P56/P00
M130 VDDPE NET667 NET689 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gfiobtpnd/P10
M131 VDDPE NET660 NET689 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gfiobtpnd/P00
M132 HNET378 NET674 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/I181/N01
M133 NET673 NET652 HNET378 VSSE NCH W=0.7U L=0.06U M=1 $name=/I181/N00
M134 VDDPE NET674 NET673 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I181/P10
M135 VDDPE NET652 NET673 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I181/P00
M136 HNET382 NET624 VSSE VSSE NCH W=1.05U L=0.06U M=1 $name=/I3/N01
M137 NET674 IOCLKNB HNET382 VSSE NCH W=1.05U L=0.06U M=1 $name=/I3/N00
M138 VDDPE NET624 NET674 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I3/P10
M139 VDDPE IOCLKNB NET674 VDDCE PCH W=1.05U L=0.06U M=1 $name=/I3/P00
M14 IODLB_ NET492 GDLBM_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P55/P00
M140 HNET386 NET612 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselnd/N01
M141 NET679 YSELA HNET386 VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselnd/N00
M142 VDDPE NET612 NET679 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselnd/P10
M143 VDDPE YSELA NET679 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselnd/P00
M144 HNET390 NET610 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/N01
M145 NET682 YSELA HNET390 VSSE NCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/N00
M146 VDDPE NET610 NET682 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/P10
M147 VDDPE YSELA NET682 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gyselfrnd/P00
M148 HNET394 NET480 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/gprennd1/N01
M149 NET685 NET636 HNET394 VSSE NCH W=1U L=0.06U M=1 $name=/gprennd1/N00
M15 IODLA_ NET682 GDLAM_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P54/P00
M150 VDDPE NET480 NET685 VDDCE PCH W=1U L=0.06U M=1 $name=/gprennd1/P10
M151 VDDPE NET636 NET685 VDDCE PCH W=1U L=0.06U M=1 $name=/gprennd1/P00
M152 HNET398 NET689 VSSE VSSE NCH W=1.54U L=0.06U M=1 $name=/gprennd/N01
M153 PRENA NET685 HNET398 VSSE NCH W=1.54U L=0.06U M=1 $name=/gprennd/N00
M154 VDDPE NET689 PRENA VDDCE PCH W=1.54U L=0.06U M=1 $name=/gprennd/P10
M155 VDDPE NET685 PRENA VDDCE PCH W=1.54U L=0.06U M=1 $name=/gprennd/P00
M156 HNET402 NET531 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I148/N01
M157 NET492 YSELB HNET402 VSSE NCH W=0.8U L=0.06U M=1 $name=/I148/N00
M158 VDDPE NET531 NET492 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I148/P10
M159 VDDPE YSELB NET492 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I148/P00
M16 IODLA NET682 GDLAM VDDCE PCH W=1.56U L=0.06U M=1 $name=/P53/P00
M160 HNET406 NET573 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I147/N01
M161 NET537 YSELB HNET406 VSSE NCH W=0.8U L=0.06U M=1 $name=/I147/N00
M162 VDDPE NET573 NET537 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I147/P10
M163 VDDPE YSELB NET537 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I147/P00
M164 HNET410 NET673 VSSE VSSE NCH W=1.54U L=0.06U M=1 $name=/I139/N01
M165 PRENB NET696 HNET410 VSSE NCH W=1.54U L=0.06U M=1 $name=/I139/N00
M166 VDDPE NET673 PRENB VDDCE PCH W=1.54U L=0.06U M=1 $name=/I139/P10
M167 VDDPE NET696 PRENB VDDCE PCH W=1.54U L=0.06U M=1 $name=/I139/P00
M168 HNET414 NET701 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I100/N01
M169 NET696 NET642 HNET414 VSSE NCH W=1U L=0.06U M=1 $name=/I100/N00
M17 WEIB NET531 NET701 VDDCE PCH W=0.4U L=0.06U M=1 $name=/P5/P00
M170 VDDPE NET701 NET696 VDDCE PCH W=1U L=0.06U M=1 $name=/I100/P10
M171 VDDPE NET642 NET696 VDDCE PCH W=1U L=0.06U M=1 $name=/I100/P00
M18 WEIA NET610 NET480 VDDCE PCH W=0.4U L=0.06U M=1 $name=/P4/P00
M19 YP_B NET674 NET569 VDDCE PCH W=0.5U L=0.06U M=1 $name=/P38/P00
M2 WEIAM NET612 NET480 VDDCE PCH W=0.4U L=0.06U M=1 $name=/tpwepass/P00
M20 IODLB NET537 GDLB VDDCE PCH W=1.56U L=0.06U M=1 $name=/P3/P00
M21 IODLA_ NET679 GDLA_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P22/P00
M22 VDDPE PRENA GDLA_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/P2/P00
M23 VDDPE PRENB GDLB_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/P19/P00
M24 GDLB PRENB GDLB_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/P17/P00
M25 VDDPE PRENB GDLB VDDCE PCH W=1.5U L=0.06U M=1 $name=/P16/P00
M26 YSNBM NET573 NET575 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P102/P00
M27 YSNB NET531 NET575 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P101/P00
M28 YSNA NET610 NET542 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P100/P00
M29 IODLB_ NET537 GDLB_ VDDCE PCH W=1.56U L=0.06U M=1 $name=/P1/P00
M3 IODLA NET679 GDLA VDDCE PCH W=1.56U L=0.06U M=1 $name=/tpgdlpg/P00
M30 NET542 NET610 YSNAM VSSE NCH W=0.15U L=0.06U M=1 $name=/tnyspass/N00
M31 NET545 DIOCLKNA YP_A VSSE NCH W=0.5U L=0.06U M=1 $name=/tnyppg/N00
M32 NET480 NET610 WEIAM VSSE NCH W=0.4U L=0.06U M=1 $name=/tnwepass/N00
M33 GDLA NET549 IODLA VSSE NCH W=1.45U L=0.06U M=1 $name=/tngdlpg/N00
M34 GDLB NET555 IODLB VSSE NCH W=1.45U L=0.06U M=1 $name=/N7/N00
M35 GDLB_ NET555 IODLB_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N6/N00
M36 NET701 NET531 WEIBM VSSE NCH W=0.4U L=0.06U M=1 $name=/N3/N00
M37 GDLA_ NET549 IODLA_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N23/N00
M38 NET701 NET573 WEIB VSSE NCH W=0.4U L=0.06U M=1 $name=/N2/N00
M39 NET569 DIOCLKNB YP_B VSSE NCH W=0.5U L=0.06U M=1 $name=/N19/N00
M4 VDDPE PRENA GDLA VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdlpchg/P00
M40 NET575 NET531 YSNBM VSSE NCH W=0.15U L=0.06U M=1 $name=/N143/N00
M41 NET575 NET573 YSNB VSSE NCH W=0.15U L=0.06U M=1 $name=/N142/N00
M42 NET542 NET612 YSNA VSSE NCH W=0.15U L=0.06U M=1 $name=/N141/N00
M43 GDLBM NET582 IODLB VSSE NCH W=1.45U L=0.06U M=1 $name=/N103/N00
M44 GDLBM_ NET582 IODLB_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N102/N00
M45 GDLAM_ NET588 IODLA_ VSSE NCH W=1.45U L=0.06U M=1 $name=/N101/N00
M46 GDLAM NET588 IODLA VSSE NCH W=1.45U L=0.06U M=1 $name=/N100/N00
M47 NET480 NET612 WEIA VSSE NCH W=0.4U L=0.06U M=1 $name=/N1/N00
M48 HNET292 NET638 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gypfb/NI00
M49 NET545 NET667 HNET292 VSSE NCH W=0.15U L=0.06U M=1 $name=/gypfb/NE00
M5 NET467 GDLA_ GDLA VDDCE PCH W=1U L=0.06U M=1 $name=/tgdlkp/P00
M50 HNET286 DIOCLKNA NET545 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gypfb/PE00
M51 VDDPE NET638 HNET286 VDDCE PCH W=0.15U L=0.06U M=1 $name=/gypfb/PI00
M52 HNET299 NET644 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I87/NI00
M53 NET569 NET674 HNET299 VSSE NCH W=0.15U L=0.06U M=1 $name=/I87/NE00
M54 HNET293 DIOCLKNB NET569 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I87/PE00
M55 VDDPE NET644 HNET293 VDDCE PCH W=0.15U L=0.06U M=1 $name=/I87/PI00
M56 HNET302 CRENA VSSE VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/gcrend/N01
M57 NET613 CRENAM HNET302 VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/gcrend/N00
M58 VDDPE CRENA NET613 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/gcrend/P10
M59 VDDPE CRENAM NET613 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/gcrend/P00
M6 GDLA PRENA GDLA_ VDDCE PCH W=1.5U L=0.06U M=1 $name=/tgdleq/P00
M60 HNET306 CRENB VSSE VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/I158/N01
M61 NET609 CRENBM HNET306 VSSE NCH_HVT W=0.36U L=0.06U M=1 $name=/I158/N00
M62 VDDPE CRENB NET609 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/I158/P10
M63 VDDPE CRENBM NET609 VDDCE PCH_HVT W=0.55U L=0.06U M=1 $name=/I158/P00
M64 NET610 NET612 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/gcreinv2/N00
M65 VDDPE NET612 NET610 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/gcreinv2/P00
M66 NET612 NET613 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gcreinv1/N00
M67 VDDPE NET613 NET612 VDDCE PCH_HVT W=0.46U L=0.06U M=1 $name=/gcreinv1/P00
M68 NET573 NET609 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I159/N00
M69 VDDPE NET609 NET573 VDDCE PCH_HVT W=0.46U L=0.06U M=1 $name=/I159/P00
M7 NET473 GDLB GDLB_ VDDCE PCH W=1U L=0.06U M=1 $name=/P98/P00
M70 NET531 NET573 VSSE VSSE NCH_HVT W=0.18U L=0.06U M=1 $name=/I149/N00
M71 VDDPE NET573 NET531 VDDCE PCH_HVT W=0.28U L=0.06U M=1 $name=/I149/P00
M72 NET623 NET661 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/giginv2/N00
M73 VDDPE NET661 NET623 VDDCE PCH W=0.8U L=0.06U M=1 $name=/giginv2/P00
M74 IOCLKNA NET623 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/giginv1/N00
M75 VDDPE NET623 IOCLKNA VDDCE PCH W=0.8U L=0.06U M=1 $name=/giginv1/P00
M76 DIOCLKNB NET674 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I33/N00
M77 VDDPE NET674 DIOCLKNB VDDCE PCH W=0.4U L=0.06U M=1 $name=/I33/P00
M78 NET624 IOBTPB VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I103/N00
M79 VDDPE IOBTPB NET624 VDDCE PCH W=0.4U L=0.06U M=1 $name=/I103/P00
M8 NET473 GDLB_ GDLB VDDCE PCH W=1U L=0.06U M=1 $name=/P97/P00
M80 NET629 NET664 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I4/N00
M81 VDDPE NET664 NET629 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I4/P00
M82 IOCLKNB NET629 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I5/N00
M83 VDDPE NET629 IOCLKNB VDDCE PCH W=0.8U L=0.06U M=1 $name=/I5/P00
M84 YSELA YSNA VSSE VSSE NCH W=0.29U L=0.06U M=1 $name=/gysna/N00
M85 VDDPE YSNA YSELA VDDCE PCH W=0.57U L=0.06U M=1 $name=/gysna/P00
M86 NET588 NET682 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/gyselfr/N00
M87 VDDPE NET682 NET588 VDDCE PCH W=0.78U L=0.06U M=1 $name=/gyselfr/P00
M88 NET549 NET679 VSSE VSSE NCH W=0.52U L=0.06U M=1 $name=/gysel/N00
M89 VDDPE NET679 NET549 VDDCE PCH W=0.78U L=0.06U M=1 $name=/gysel/P00
M9 VDDPE NET701 NET473 VDDCE PCH W=1U L=0.06U M=1 $name=/P96/P00
M90 NET636 NET542 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/gypinv1/N00
M91 VDDPE NET542 NET636 VDDCE PCH W=0.35U L=0.06U M=1 $name=/gypinv1/P00
M92 NET638 NET545 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gypinv/N00
M93 VDDPE NET545 NET638 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gypinv/P00
M94 DIOCLKNA NET667 VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/ginvpass1/N00
M95 VDDPE NET667 DIOCLKNA VDDCE PCH W=0.4U L=0.06U M=1 $name=/ginvpass1/P00
M96 NET660 FIOBTPA VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/gfiobtp/N00
M97 VDDPE FIOBTPA NET660 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gfiobtp/P00
M98 NET642 NET575 VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I86/N00
M99 VDDPE NET575 NET642 VDDCE PCH W=0.35U L=0.06U M=1 $name=/I86/P00
.ENDS pe_spad_1024x16_dpFLIO4
****
.SUBCKT pe_spad_1024x16_dpIOX BWEIA BWEIB CRENAJ CRENBJ DNA DNB FIOBTPA
+  FIOBTPB GDLA_0 GDLA_1 GDLA_2 GDLA_3 GDLA__0 GDLA__1 GDLA__2 GDLA__3 GDLB_0
+  GDLB_1 GDLB_2 GDLB_3 GDLB__0 GDLB__1 GDLB__2 GDLB__3 IOBTPA IOBTPB IRET
+  ORET QA_ QB_ STUB_BLA0_0 STUB_BLA0_1 STUB_BLA0_2 STUB_BLA0_3 STUB_BLA0__0
+  STUB_BLA0__1 STUB_BLA0__2 STUB_BLA0__3 STUB_BLA1_0 STUB_BLA1_1 STUB_BLA1_2
+  STUB_BLA1_3 STUB_BLA1__0 STUB_BLA1__1 STUB_BLA1__2 STUB_BLA1__3 STUB_BLA2_0
+  STUB_BLA2_1 STUB_BLA2_2 STUB_BLA2_3 STUB_BLA2__0 STUB_BLA2__1 STUB_BLA2__2
+  STUB_BLA2__3 STUB_BLA3_0 STUB_BLA3_1 STUB_BLA3_2 STUB_BLA3_3 STUB_BLA3__0
+  STUB_BLA3__1 STUB_BLA3__2 STUB_BLA3__3 STUB_BLB0_0 STUB_BLB0_1 STUB_BLB0_2
+  STUB_BLB0_3 STUB_BLB0__0 STUB_BLB0__1 STUB_BLB0__2 STUB_BLB0__3 STUB_BLB1_0
+  STUB_BLB1_1 STUB_BLB1_2 STUB_BLB1_3 STUB_BLB1__0 STUB_BLB1__1 STUB_BLB1__2
+  STUB_BLB1__3 STUB_BLB2_0 STUB_BLB2_1 STUB_BLB2_2 STUB_BLB2_3 STUB_BLB2__0
+  STUB_BLB2__1 STUB_BLB2__2 STUB_BLB2__3 STUB_BLB3_0 STUB_BLB3_1 STUB_BLB3_2
+  STUB_BLB3_3 STUB_BLB3__0 STUB_BLB3__1 STUB_BLB3__2 STUB_BLB3__3 TIEHI TIELO
+  WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B
+  VDDPE VDDCE VSSE
** pe_spad_1024x16_dpIOX: 854 flat devices **
XI0_0 BWEIA BWEIB CRENAJ CRENAJ CRENAJ CRENAJ CRENBJ CRENBJ CRENBJ CRENBJ DNA
+  DNB FIOBTPA FIOBTPB GDLA_0 GDLAI GDLAI_ VSSE VSSE GDLAI GDLAI_ GDLA__0
+  GDLB_0 GDLBI GDLBI_ VSSE VSSE GDLBI GDLBI_ GDLB__0 IOBTPA IOBTPB IODLA
+  IODLA_ IODLB IODLB_ IRET ORET QA_ QB_ TIELO TIELO STUB_BLA0_0 STUB_BLA0__0
+  STUB_BLA1_0 STUB_BLA1__0 STUB_BLA2_0 STUB_BLA2__0 STUB_BLA3_0 STUB_BLA3__0
+  STUB_BLB0_0 STUB_BLB0__0 STUB_BLB1_0 STUB_BLB1__0 STUB_BLB2_0 STUB_BLB2__0
+  STUB_BLB3_0 STUB_BLB3__0 TIEHI TIELO WEA WEB WEIA VSSE VSSE VSSE WEIB VSSE
+  VSSE VSSE YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B
+  YP1_0_A YP1_0_B YSNA VSSE VSSE VSSE YSNB VSSE VSSE VSSE VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpIO4
XI1_0 CRENAJ CRENAJ CRENAJ CRENAJ CRENBJ CRENBJ CRENBJ CRENBJ FIOBTPA FIOBTPB
+  GDLA_1 GDLAI GDLAI_ VSSE VSSE GDLAI GDLAI_ GDLA__1 GDLB_1 GDLBI GDLBI_ VSSE
+  VSSE GDLBI GDLBI_ GDLB__1 IOBTPA IOBTPB IODLA IODLA_ IODLB IODLB_ IRET ORET
+  STUB_BLA0_1 STUB_BLA0__1 STUB_BLA1_1 STUB_BLA1__1 STUB_BLA2_1 STUB_BLA2__1
+  STUB_BLA3_1 STUB_BLA3__1 STUB_BLB0_1 STUB_BLB0__1 STUB_BLB1_1 STUB_BLB1__1
+  STUB_BLB2_1 STUB_BLB2__1 STUB_BLB3_1 STUB_BLB3__1 TIEHI TIELO WEA WEB WEIA
+  VSSE VSSE VSSE WEIB VSSE VSSE VSSE YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A
+  YP1_2_B YP1_3_A YP1_3_B YP1_1_A YP1_1_B YSNA_12 VSSE VSSE VSSE YSNB_14 VSSE
+  VSSE VSSE VDDPE VDDCE VSSE pe_spad_1024x16_dpFLIO4
XI2_0 CRENAJ CRENAJ CRENAJ CRENAJ CRENBJ CRENBJ CRENBJ CRENBJ FIOBTPA FIOBTPB
+  GDLA_2 VSSE VSSE VSSE VSSE VSSE VSSE GDLA__2 GDLB_2 VSSE VSSE VSSE VSSE
+  VSSE VSSE GDLB__2 IOBTPA IOBTPB IODLA IODLA_ IODLB IODLB_ IRET ORET
+  STUB_BLA0_2 STUB_BLA0__2 STUB_BLA1_2 STUB_BLA1__2 STUB_BLA2_2 STUB_BLA2__2
+  STUB_BLA3_2 STUB_BLA3__2 STUB_BLB0_2 STUB_BLB0__2 STUB_BLB1_2 STUB_BLB1__2
+  STUB_BLB2_2 STUB_BLB2__2 STUB_BLB3_2 STUB_BLB3__2 TIEHI TIELO WEA WEB WEIA
+  VSSE VSSE VSSE WEIB VSSE VSSE VSSE YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A
+  YP1_2_B YP1_3_A YP1_3_B YP1_2_A YP1_2_B YSNA_16 VSSE VSSE VSSE YSNB_18 VSSE
+  VSSE VSSE VDDPE VDDCE VSSE pe_spad_1024x16_dpFLIO4
XI3_0 CRENAJ CRENAJ CRENAJ CRENAJ CRENBJ CRENBJ CRENBJ CRENBJ FIOBTPA FIOBTPB
+  GDLA_3 VSSE VSSE VSSE VSSE VSSE VSSE GDLA__3 GDLB_3 VSSE VSSE VSSE VSSE
+  VSSE VSSE GDLB__3 IOBTPA IOBTPB IODLA IODLA_ IODLB IODLB_ IRET ORET
+  STUB_BLA0_3 STUB_BLA0__3 STUB_BLA1_3 STUB_BLA1__3 STUB_BLA2_3 STUB_BLA2__3
+  STUB_BLA3_3 STUB_BLA3__3 STUB_BLB0_3 STUB_BLB0__3 STUB_BLB1_3 STUB_BLB1__3
+  STUB_BLB2_3 STUB_BLB2__3 STUB_BLB3_3 STUB_BLB3__3 TIEHI TIELO WEA WEB WEIA
+  VSSE VSSE VSSE WEIB VSSE VSSE VSSE YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A
+  YP1_2_B YP1_3_A YP1_3_B YP1_3_A YP1_3_B YSNA_20 VSSE VSSE VSSE YSNB_22 VSSE
+  VSSE VSSE VDDPE VDDCE VSSE pe_spad_1024x16_dpFLIO4
.ENDS pe_spad_1024x16_dpIOX
****
.SUBCKT pe_spad_1024x16_dpIO_ROW_L BWEIA_0 BWEIA_1 BWEIA_2 BWEIA_3 BWEIA_4
+  BWEIA_5 BWEIA_6 BWEIA_7 BWEIB_0 BWEIB_1 BWEIB_2 BWEIB_3 BWEIB_4 BWEIB_5
+  BWEIB_6 BWEIB_7 CRENA DNA_0 DNA_1 DNA_2 DNA_3 DNA_4 DNA_5 DNA_6 DNA_7 DNB_0
+  DNB_1 DNB_2 DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 FIOBTPA FIOBTPB GDLA_0 GDLA_1
+  GDLA_2 GDLA_3 GDLA_4 GDLA_5 GDLA_6 GDLA_7 GDLA_8 GDLA_9 GDLA_10 GDLA_11
+  GDLA_12 GDLA_13 GDLA_14 GDLA_15 GDLA_16 GDLA_17 GDLA_18 GDLA_19 GDLA_20
+  GDLA_21 GDLA_22 GDLA_23 GDLA_24 GDLA_25 GDLA_26 GDLA_27 GDLA_28 GDLA_29
+  GDLA_30 GDLA_31 GDLA__0 GDLA__1 GDLA__2 GDLA__3 GDLA__4 GDLA__5 GDLA__6
+  GDLA__7 GDLA__8 GDLA__9 GDLA__10 GDLA__11 GDLA__12 GDLA__13 GDLA__14
+  GDLA__15 GDLA__16 GDLA__17 GDLA__18 GDLA__19 GDLA__20 GDLA__21 GDLA__22
+  GDLA__23 GDLA__24 GDLA__25 GDLA__26 GDLA__27 GDLA__28 GDLA__29 GDLA__30
+  GDLA__31 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6 GDLB_7 GDLB_8
+  GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15 GDLB_16 GDLB_17
+  GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23 GDLB_24 GDLB_25 GDLB_26
+  GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB__0 GDLB__1 GDLB__2 GDLB__3
+  GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8 GDLB__9 GDLB__10 GDLB__11 GDLB__12
+  GDLB__13 GDLB__14 GDLB__15 GDLB__16 GDLB__17 GDLB__18 GDLB__19 GDLB__20
+  GDLB__21 GDLB__22 GDLB__23 GDLB__24 GDLB__25 GDLB__26 GDLB__27 GDLB__28
+  GDLB__29 GDLB__30 GDLB__31 IOBTPA IOBTPB IRET ORET QA__0 QA__1 QA__2 QA__3
+  QA__4 QA__5 QA__6 QA__7 QB__0 QB__1 QB__2 QB__3 QB__4 QB__5 QB__6 QB__7
+  STUB_BLA0_0 STUB_BLA0_1 STUB_BLA0_2 STUB_BLA0_3 STUB_BLA0_4 STUB_BLA0_5
+  STUB_BLA0_6 STUB_BLA0_7 STUB_BLA0_8 STUB_BLA0_9 STUB_BLA0_10 STUB_BLA0_11
+  STUB_BLA0_12 STUB_BLA0_13 STUB_BLA0_14 STUB_BLA0_15 STUB_BLA0_16
+  STUB_BLA0_17 STUB_BLA0_18 STUB_BLA0_19 STUB_BLA0_20 STUB_BLA0_21
+  STUB_BLA0_22 STUB_BLA0_23 STUB_BLA0_24 STUB_BLA0_25 STUB_BLA0_26
+  STUB_BLA0_27 STUB_BLA0_28 STUB_BLA0_29 STUB_BLA0_30 STUB_BLA0_31
+  STUB_BLA0__0 STUB_BLA0__1 STUB_BLA0__2 STUB_BLA0__3 STUB_BLA0__4
+  STUB_BLA0__5 STUB_BLA0__6 STUB_BLA0__7 STUB_BLA0__8 STUB_BLA0__9
+  STUB_BLA0__10 STUB_BLA0__11 STUB_BLA0__12 STUB_BLA0__13 STUB_BLA0__14
+  STUB_BLA0__15 STUB_BLA0__16 STUB_BLA0__17 STUB_BLA0__18 STUB_BLA0__19
+  STUB_BLA0__20 STUB_BLA0__21 STUB_BLA0__22 STUB_BLA0__23 STUB_BLA0__24
+  STUB_BLA0__25 STUB_BLA0__26 STUB_BLA0__27 STUB_BLA0__28 STUB_BLA0__29
+  STUB_BLA0__30 STUB_BLA0__31 STUB_BLA1_0 STUB_BLA1_1 STUB_BLA1_2 STUB_BLA1_3
+  STUB_BLA1_4 STUB_BLA1_5 STUB_BLA1_6 STUB_BLA1_7 STUB_BLA1_8 STUB_BLA1_9
+  STUB_BLA1_10 STUB_BLA1_11 STUB_BLA1_12 STUB_BLA1_13 STUB_BLA1_14
+  STUB_BLA1_15 STUB_BLA1_16 STUB_BLA1_17 STUB_BLA1_18 STUB_BLA1_19
+  STUB_BLA1_20 STUB_BLA1_21 STUB_BLA1_22 STUB_BLA1_23 STUB_BLA1_24
+  STUB_BLA1_25 STUB_BLA1_26 STUB_BLA1_27 STUB_BLA1_28 STUB_BLA1_29
+  STUB_BLA1_30 STUB_BLA1_31 STUB_BLA1__0 STUB_BLA1__1 STUB_BLA1__2
+  STUB_BLA1__3 STUB_BLA1__4 STUB_BLA1__5 STUB_BLA1__6 STUB_BLA1__7
+  STUB_BLA1__8 STUB_BLA1__9 STUB_BLA1__10 STUB_BLA1__11 STUB_BLA1__12
+  STUB_BLA1__13 STUB_BLA1__14 STUB_BLA1__15 STUB_BLA1__16 STUB_BLA1__17
+  STUB_BLA1__18 STUB_BLA1__19 STUB_BLA1__20 STUB_BLA1__21 STUB_BLA1__22
+  STUB_BLA1__23 STUB_BLA1__24 STUB_BLA1__25 STUB_BLA1__26 STUB_BLA1__27
+  STUB_BLA1__28 STUB_BLA1__29 STUB_BLA1__30 STUB_BLA1__31 STUB_BLA2_0
+  STUB_BLA2_1 STUB_BLA2_2 STUB_BLA2_3 STUB_BLA2_4 STUB_BLA2_5 STUB_BLA2_6
+  STUB_BLA2_7 STUB_BLA2_8 STUB_BLA2_9 STUB_BLA2_10 STUB_BLA2_11 STUB_BLA2_12
+  STUB_BLA2_13 STUB_BLA2_14 STUB_BLA2_15 STUB_BLA2_16 STUB_BLA2_17
+  STUB_BLA2_18 STUB_BLA2_19 STUB_BLA2_20 STUB_BLA2_21 STUB_BLA2_22
+  STUB_BLA2_23 STUB_BLA2_24 STUB_BLA2_25 STUB_BLA2_26 STUB_BLA2_27
+  STUB_BLA2_28 STUB_BLA2_29 STUB_BLA2_30 STUB_BLA2_31 STUB_BLA2__0
+  STUB_BLA2__1 STUB_BLA2__2 STUB_BLA2__3 STUB_BLA2__4 STUB_BLA2__5
+  STUB_BLA2__6 STUB_BLA2__7 STUB_BLA2__8 STUB_BLA2__9 STUB_BLA2__10
+  STUB_BLA2__11 STUB_BLA2__12 STUB_BLA2__13 STUB_BLA2__14 STUB_BLA2__15
+  STUB_BLA2__16 STUB_BLA2__17 STUB_BLA2__18 STUB_BLA2__19 STUB_BLA2__20
+  STUB_BLA2__21 STUB_BLA2__22 STUB_BLA2__23 STUB_BLA2__24 STUB_BLA2__25
+  STUB_BLA2__26 STUB_BLA2__27 STUB_BLA2__28 STUB_BLA2__29 STUB_BLA2__30
+  STUB_BLA2__31 STUB_BLA3_0 STUB_BLA3_1 STUB_BLA3_2 STUB_BLA3_3 STUB_BLA3_4
+  STUB_BLA3_5 STUB_BLA3_6 STUB_BLA3_7 STUB_BLA3_8 STUB_BLA3_9 STUB_BLA3_10
+  STUB_BLA3_11 STUB_BLA3_12 STUB_BLA3_13 STUB_BLA3_14 STUB_BLA3_15
+  STUB_BLA3_16 STUB_BLA3_17 STUB_BLA3_18 STUB_BLA3_19 STUB_BLA3_20
+  STUB_BLA3_21 STUB_BLA3_22 STUB_BLA3_23 STUB_BLA3_24 STUB_BLA3_25
+  STUB_BLA3_26 STUB_BLA3_27 STUB_BLA3_28 STUB_BLA3_29 STUB_BLA3_30
+  STUB_BLA3_31 STUB_BLA3__0 STUB_BLA3__1 STUB_BLA3__2 STUB_BLA3__3
+  STUB_BLA3__4 STUB_BLA3__5 STUB_BLA3__6 STUB_BLA3__7 STUB_BLA3__8
+  STUB_BLA3__9 STUB_BLA3__10 STUB_BLA3__11 STUB_BLA3__12 STUB_BLA3__13
+  STUB_BLA3__14 STUB_BLA3__15 STUB_BLA3__16 STUB_BLA3__17 STUB_BLA3__18
+  STUB_BLA3__19 STUB_BLA3__20 STUB_BLA3__21 STUB_BLA3__22 STUB_BLA3__23
+  STUB_BLA3__24 STUB_BLA3__25 STUB_BLA3__26 STUB_BLA3__27 STUB_BLA3__28
+  STUB_BLA3__29 STUB_BLA3__30 STUB_BLA3__31 STUB_BLB0_0 STUB_BLB0_1
+  STUB_BLB0_2 STUB_BLB0_3 STUB_BLB0_4 STUB_BLB0_5 STUB_BLB0_6 STUB_BLB0_7
+  STUB_BLB0_8 STUB_BLB0_9 STUB_BLB0_10 STUB_BLB0_11 STUB_BLB0_12 STUB_BLB0_13
+  STUB_BLB0_14 STUB_BLB0_15 STUB_BLB0_16 STUB_BLB0_17 STUB_BLB0_18
+  STUB_BLB0_19 STUB_BLB0_20 STUB_BLB0_21 STUB_BLB0_22 STUB_BLB0_23
+  STUB_BLB0_24 STUB_BLB0_25 STUB_BLB0_26 STUB_BLB0_27 STUB_BLB0_28
+  STUB_BLB0_29 STUB_BLB0_30 STUB_BLB0_31 STUB_BLB0__0 STUB_BLB0__1
+  STUB_BLB0__2 STUB_BLB0__3 STUB_BLB0__4 STUB_BLB0__5 STUB_BLB0__6
+  STUB_BLB0__7 STUB_BLB0__8 STUB_BLB0__9 STUB_BLB0__10 STUB_BLB0__11
+  STUB_BLB0__12 STUB_BLB0__13 STUB_BLB0__14 STUB_BLB0__15 STUB_BLB0__16
+  STUB_BLB0__17 STUB_BLB0__18 STUB_BLB0__19 STUB_BLB0__20 STUB_BLB0__21
+  STUB_BLB0__22 STUB_BLB0__23 STUB_BLB0__24 STUB_BLB0__25 STUB_BLB0__26
+  STUB_BLB0__27 STUB_BLB0__28 STUB_BLB0__29 STUB_BLB0__30 STUB_BLB0__31
+  STUB_BLB1_0 STUB_BLB1_1 STUB_BLB1_2 STUB_BLB1_3 STUB_BLB1_4 STUB_BLB1_5
+  STUB_BLB1_6 STUB_BLB1_7 STUB_BLB1_8 STUB_BLB1_9 STUB_BLB1_10 STUB_BLB1_11
+  STUB_BLB1_12 STUB_BLB1_13 STUB_BLB1_14 STUB_BLB1_15 STUB_BLB1_16
+  STUB_BLB1_17 STUB_BLB1_18 STUB_BLB1_19 STUB_BLB1_20 STUB_BLB1_21
+  STUB_BLB1_22 STUB_BLB1_23 STUB_BLB1_24 STUB_BLB1_25 STUB_BLB1_26
+  STUB_BLB1_27 STUB_BLB1_28 STUB_BLB1_29 STUB_BLB1_30 STUB_BLB1_31
+  STUB_BLB1__0 STUB_BLB1__1 STUB_BLB1__2 STUB_BLB1__3 STUB_BLB1__4
+  STUB_BLB1__5 STUB_BLB1__6 STUB_BLB1__7 STUB_BLB1__8 STUB_BLB1__9
+  STUB_BLB1__10 STUB_BLB1__11 STUB_BLB1__12 STUB_BLB1__13 STUB_BLB1__14
+  STUB_BLB1__15 STUB_BLB1__16 STUB_BLB1__17 STUB_BLB1__18 STUB_BLB1__19
+  STUB_BLB1__20 STUB_BLB1__21 STUB_BLB1__22 STUB_BLB1__23 STUB_BLB1__24
+  STUB_BLB1__25 STUB_BLB1__26 STUB_BLB1__27 STUB_BLB1__28 STUB_BLB1__29
+  STUB_BLB1__30 STUB_BLB1__31 STUB_BLB2_0 STUB_BLB2_1 STUB_BLB2_2 STUB_BLB2_3
+  STUB_BLB2_4 STUB_BLB2_5 STUB_BLB2_6 STUB_BLB2_7 STUB_BLB2_8 STUB_BLB2_9
+  STUB_BLB2_10 STUB_BLB2_11 STUB_BLB2_12 STUB_BLB2_13 STUB_BLB2_14
+  STUB_BLB2_15 STUB_BLB2_16 STUB_BLB2_17 STUB_BLB2_18 STUB_BLB2_19
+  STUB_BLB2_20 STUB_BLB2_21 STUB_BLB2_22 STUB_BLB2_23 STUB_BLB2_24
+  STUB_BLB2_25 STUB_BLB2_26 STUB_BLB2_27 STUB_BLB2_28 STUB_BLB2_29
+  STUB_BLB2_30 STUB_BLB2_31 STUB_BLB2__0 STUB_BLB2__1 STUB_BLB2__2
+  STUB_BLB2__3 STUB_BLB2__4 STUB_BLB2__5 STUB_BLB2__6 STUB_BLB2__7
+  STUB_BLB2__8 STUB_BLB2__9 STUB_BLB2__10 STUB_BLB2__11 STUB_BLB2__12
+  STUB_BLB2__13 STUB_BLB2__14 STUB_BLB2__15 STUB_BLB2__16 STUB_BLB2__17
+  STUB_BLB2__18 STUB_BLB2__19 STUB_BLB2__20 STUB_BLB2__21 STUB_BLB2__22
+  STUB_BLB2__23 STUB_BLB2__24 STUB_BLB2__25 STUB_BLB2__26 STUB_BLB2__27
+  STUB_BLB2__28 STUB_BLB2__29 STUB_BLB2__30 STUB_BLB2__31 STUB_BLB3_0
+  STUB_BLB3_1 STUB_BLB3_2 STUB_BLB3_3 STUB_BLB3_4 STUB_BLB3_5 STUB_BLB3_6
+  STUB_BLB3_7 STUB_BLB3_8 STUB_BLB3_9 STUB_BLB3_10 STUB_BLB3_11 STUB_BLB3_12
+  STUB_BLB3_13 STUB_BLB3_14 STUB_BLB3_15 STUB_BLB3_16 STUB_BLB3_17
+  STUB_BLB3_18 STUB_BLB3_19 STUB_BLB3_20 STUB_BLB3_21 STUB_BLB3_22
+  STUB_BLB3_23 STUB_BLB3_24 STUB_BLB3_25 STUB_BLB3_26 STUB_BLB3_27
+  STUB_BLB3_28 STUB_BLB3_29 STUB_BLB3_30 STUB_BLB3_31 STUB_BLB3__0
+  STUB_BLB3__1 STUB_BLB3__2 STUB_BLB3__3 STUB_BLB3__4 STUB_BLB3__5
+  STUB_BLB3__6 STUB_BLB3__7 STUB_BLB3__8 STUB_BLB3__9 STUB_BLB3__10
+  STUB_BLB3__11 STUB_BLB3__12 STUB_BLB3__13 STUB_BLB3__14 STUB_BLB3__15
+  STUB_BLB3__16 STUB_BLB3__17 STUB_BLB3__18 STUB_BLB3__19 STUB_BLB3__20
+  STUB_BLB3__21 STUB_BLB3__22 STUB_BLB3__23 STUB_BLB3__24 STUB_BLB3__25
+  STUB_BLB3__26 STUB_BLB3__27 STUB_BLB3__28 STUB_BLB3__29 STUB_BLB3__30
+  STUB_BLB3__31 TIELO WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B
+  YP1_3_A YP1_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpIO_ROW_L: 6832 flat devices **
XI0_0 BWEIA_0 BWEIB_0 CRENA CRENA DNA_0 DNB_0 FIOBTPA FIOBTPB GDLA_0 GDLA_1
+  GDLA_2 GDLA_3 GDLA__0 GDLA__1 GDLA__2 GDLA__3 GDLB_0 GDLB_1 GDLB_2 GDLB_3
+  GDLB__0 GDLB__1 GDLB__2 GDLB__3 IOBTPA IOBTPB IRET ORET QA__0 QB__0
+  STUB_BLA0_0 STUB_BLA0_1 STUB_BLA0_2 STUB_BLA0_3 STUB_BLA0__0 STUB_BLA0__1
+  STUB_BLA0__2 STUB_BLA0__3 STUB_BLA1_0 STUB_BLA1_1 STUB_BLA1_2 STUB_BLA1_3
+  STUB_BLA1__0 STUB_BLA1__1 STUB_BLA1__2 STUB_BLA1__3 STUB_BLA2_0 STUB_BLA2_1
+  STUB_BLA2_2 STUB_BLA2_3 STUB_BLA2__0 STUB_BLA2__1 STUB_BLA2__2 STUB_BLA2__3
+  STUB_BLA3_0 STUB_BLA3_1 STUB_BLA3_2 STUB_BLA3_3 STUB_BLA3__0 STUB_BLA3__1
+  STUB_BLA3__2 STUB_BLA3__3 STUB_BLB0_0 STUB_BLB0_1 STUB_BLB0_2 STUB_BLB0_3
+  STUB_BLB0__0 STUB_BLB0__1 STUB_BLB0__2 STUB_BLB0__3 STUB_BLB1_0 STUB_BLB1_1
+  STUB_BLB1_2 STUB_BLB1_3 STUB_BLB1__0 STUB_BLB1__1 STUB_BLB1__2 STUB_BLB1__3
+  STUB_BLB2_0 STUB_BLB2_1 STUB_BLB2_2 STUB_BLB2_3 STUB_BLB2__0 STUB_BLB2__1
+  STUB_BLB2__2 STUB_BLB2__3 STUB_BLB3_0 STUB_BLB3_1 STUB_BLB3_2 STUB_BLB3_3
+  STUB_BLB3__0 STUB_BLB3__1 STUB_BLB3__2 STUB_BLB3__3 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI1_0 BWEIA_1 BWEIB_1 CRENA CRENA DNA_1 DNB_1 FIOBTPA FIOBTPB GDLA_4 GDLA_5
+  GDLA_6 GDLA_7 GDLA__4 GDLA__5 GDLA__6 GDLA__7 GDLB_4 GDLB_5 GDLB_6 GDLB_7
+  GDLB__4 GDLB__5 GDLB__6 GDLB__7 IOBTPA IOBTPB IRET ORET QA__1 QB__1
+  STUB_BLA0_4 STUB_BLA0_5 STUB_BLA0_6 STUB_BLA0_7 STUB_BLA0__4 STUB_BLA0__5
+  STUB_BLA0__6 STUB_BLA0__7 STUB_BLA1_4 STUB_BLA1_5 STUB_BLA1_6 STUB_BLA1_7
+  STUB_BLA1__4 STUB_BLA1__5 STUB_BLA1__6 STUB_BLA1__7 STUB_BLA2_4 STUB_BLA2_5
+  STUB_BLA2_6 STUB_BLA2_7 STUB_BLA2__4 STUB_BLA2__5 STUB_BLA2__6 STUB_BLA2__7
+  STUB_BLA3_4 STUB_BLA3_5 STUB_BLA3_6 STUB_BLA3_7 STUB_BLA3__4 STUB_BLA3__5
+  STUB_BLA3__6 STUB_BLA3__7 STUB_BLB0_4 STUB_BLB0_5 STUB_BLB0_6 STUB_BLB0_7
+  STUB_BLB0__4 STUB_BLB0__5 STUB_BLB0__6 STUB_BLB0__7 STUB_BLB1_4 STUB_BLB1_5
+  STUB_BLB1_6 STUB_BLB1_7 STUB_BLB1__4 STUB_BLB1__5 STUB_BLB1__6 STUB_BLB1__7
+  STUB_BLB2_4 STUB_BLB2_5 STUB_BLB2_6 STUB_BLB2_7 STUB_BLB2__4 STUB_BLB2__5
+  STUB_BLB2__6 STUB_BLB2__7 STUB_BLB3_4 STUB_BLB3_5 STUB_BLB3_6 STUB_BLB3_7
+  STUB_BLB3__4 STUB_BLB3__5 STUB_BLB3__6 STUB_BLB3__7 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI2_0 BWEIA_2 BWEIB_2 CRENA CRENA DNA_2 DNB_2 FIOBTPA FIOBTPB GDLA_8 GDLA_9
+  GDLA_10 GDLA_11 GDLA__8 GDLA__9 GDLA__10 GDLA__11 GDLB_8 GDLB_9 GDLB_10
+  GDLB_11 GDLB__8 GDLB__9 GDLB__10 GDLB__11 IOBTPA IOBTPB IRET ORET QA__2
+  QB__2 STUB_BLA0_8 STUB_BLA0_9 STUB_BLA0_10 STUB_BLA0_11 STUB_BLA0__8
+  STUB_BLA0__9 STUB_BLA0__10 STUB_BLA0__11 STUB_BLA1_8 STUB_BLA1_9
+  STUB_BLA1_10 STUB_BLA1_11 STUB_BLA1__8 STUB_BLA1__9 STUB_BLA1__10
+  STUB_BLA1__11 STUB_BLA2_8 STUB_BLA2_9 STUB_BLA2_10 STUB_BLA2_11
+  STUB_BLA2__8 STUB_BLA2__9 STUB_BLA2__10 STUB_BLA2__11 STUB_BLA3_8
+  STUB_BLA3_9 STUB_BLA3_10 STUB_BLA3_11 STUB_BLA3__8 STUB_BLA3__9
+  STUB_BLA3__10 STUB_BLA3__11 STUB_BLB0_8 STUB_BLB0_9 STUB_BLB0_10
+  STUB_BLB0_11 STUB_BLB0__8 STUB_BLB0__9 STUB_BLB0__10 STUB_BLB0__11
+  STUB_BLB1_8 STUB_BLB1_9 STUB_BLB1_10 STUB_BLB1_11 STUB_BLB1__8 STUB_BLB1__9
+  STUB_BLB1__10 STUB_BLB1__11 STUB_BLB2_8 STUB_BLB2_9 STUB_BLB2_10
+  STUB_BLB2_11 STUB_BLB2__8 STUB_BLB2__9 STUB_BLB2__10 STUB_BLB2__11
+  STUB_BLB3_8 STUB_BLB3_9 STUB_BLB3_10 STUB_BLB3_11 STUB_BLB3__8 STUB_BLB3__9
+  STUB_BLB3__10 STUB_BLB3__11 CRENA TIELO WEA WEB YP1_0_A YP1_0_B YP1_1_A
+  YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpIOX
XI3_0 BWEIA_3 BWEIB_3 CRENA CRENA DNA_3 DNB_3 FIOBTPA FIOBTPB GDLA_12 GDLA_13
+  GDLA_14 GDLA_15 GDLA__12 GDLA__13 GDLA__14 GDLA__15 GDLB_12 GDLB_13 GDLB_14
+  GDLB_15 GDLB__12 GDLB__13 GDLB__14 GDLB__15 IOBTPA IOBTPB IRET ORET QA__3
+  QB__3 STUB_BLA0_12 STUB_BLA0_13 STUB_BLA0_14 STUB_BLA0_15 STUB_BLA0__12
+  STUB_BLA0__13 STUB_BLA0__14 STUB_BLA0__15 STUB_BLA1_12 STUB_BLA1_13
+  STUB_BLA1_14 STUB_BLA1_15 STUB_BLA1__12 STUB_BLA1__13 STUB_BLA1__14
+  STUB_BLA1__15 STUB_BLA2_12 STUB_BLA2_13 STUB_BLA2_14 STUB_BLA2_15
+  STUB_BLA2__12 STUB_BLA2__13 STUB_BLA2__14 STUB_BLA2__15 STUB_BLA3_12
+  STUB_BLA3_13 STUB_BLA3_14 STUB_BLA3_15 STUB_BLA3__12 STUB_BLA3__13
+  STUB_BLA3__14 STUB_BLA3__15 STUB_BLB0_12 STUB_BLB0_13 STUB_BLB0_14
+  STUB_BLB0_15 STUB_BLB0__12 STUB_BLB0__13 STUB_BLB0__14 STUB_BLB0__15
+  STUB_BLB1_12 STUB_BLB1_13 STUB_BLB1_14 STUB_BLB1_15 STUB_BLB1__12
+  STUB_BLB1__13 STUB_BLB1__14 STUB_BLB1__15 STUB_BLB2_12 STUB_BLB2_13
+  STUB_BLB2_14 STUB_BLB2_15 STUB_BLB2__12 STUB_BLB2__13 STUB_BLB2__14
+  STUB_BLB2__15 STUB_BLB3_12 STUB_BLB3_13 STUB_BLB3_14 STUB_BLB3_15
+  STUB_BLB3__12 STUB_BLB3__13 STUB_BLB3__14 STUB_BLB3__15 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI4_0 BWEIA_4 BWEIB_4 CRENA CRENA DNA_4 DNB_4 FIOBTPA FIOBTPB GDLA_16 GDLA_17
+  GDLA_18 GDLA_19 GDLA__16 GDLA__17 GDLA__18 GDLA__19 GDLB_16 GDLB_17 GDLB_18
+  GDLB_19 GDLB__16 GDLB__17 GDLB__18 GDLB__19 IOBTPA IOBTPB IRET ORET QA__4
+  QB__4 STUB_BLA0_16 STUB_BLA0_17 STUB_BLA0_18 STUB_BLA0_19 STUB_BLA0__16
+  STUB_BLA0__17 STUB_BLA0__18 STUB_BLA0__19 STUB_BLA1_16 STUB_BLA1_17
+  STUB_BLA1_18 STUB_BLA1_19 STUB_BLA1__16 STUB_BLA1__17 STUB_BLA1__18
+  STUB_BLA1__19 STUB_BLA2_16 STUB_BLA2_17 STUB_BLA2_18 STUB_BLA2_19
+  STUB_BLA2__16 STUB_BLA2__17 STUB_BLA2__18 STUB_BLA2__19 STUB_BLA3_16
+  STUB_BLA3_17 STUB_BLA3_18 STUB_BLA3_19 STUB_BLA3__16 STUB_BLA3__17
+  STUB_BLA3__18 STUB_BLA3__19 STUB_BLB0_16 STUB_BLB0_17 STUB_BLB0_18
+  STUB_BLB0_19 STUB_BLB0__16 STUB_BLB0__17 STUB_BLB0__18 STUB_BLB0__19
+  STUB_BLB1_16 STUB_BLB1_17 STUB_BLB1_18 STUB_BLB1_19 STUB_BLB1__16
+  STUB_BLB1__17 STUB_BLB1__18 STUB_BLB1__19 STUB_BLB2_16 STUB_BLB2_17
+  STUB_BLB2_18 STUB_BLB2_19 STUB_BLB2__16 STUB_BLB2__17 STUB_BLB2__18
+  STUB_BLB2__19 STUB_BLB3_16 STUB_BLB3_17 STUB_BLB3_18 STUB_BLB3_19
+  STUB_BLB3__16 STUB_BLB3__17 STUB_BLB3__18 STUB_BLB3__19 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI5_0 BWEIA_5 BWEIB_5 CRENA CRENA DNA_5 DNB_5 FIOBTPA FIOBTPB GDLA_20 GDLA_21
+  GDLA_22 GDLA_23 GDLA__20 GDLA__21 GDLA__22 GDLA__23 GDLB_20 GDLB_21 GDLB_22
+  GDLB_23 GDLB__20 GDLB__21 GDLB__22 GDLB__23 IOBTPA IOBTPB IRET ORET QA__5
+  QB__5 STUB_BLA0_20 STUB_BLA0_21 STUB_BLA0_22 STUB_BLA0_23 STUB_BLA0__20
+  STUB_BLA0__21 STUB_BLA0__22 STUB_BLA0__23 STUB_BLA1_20 STUB_BLA1_21
+  STUB_BLA1_22 STUB_BLA1_23 STUB_BLA1__20 STUB_BLA1__21 STUB_BLA1__22
+  STUB_BLA1__23 STUB_BLA2_20 STUB_BLA2_21 STUB_BLA2_22 STUB_BLA2_23
+  STUB_BLA2__20 STUB_BLA2__21 STUB_BLA2__22 STUB_BLA2__23 STUB_BLA3_20
+  STUB_BLA3_21 STUB_BLA3_22 STUB_BLA3_23 STUB_BLA3__20 STUB_BLA3__21
+  STUB_BLA3__22 STUB_BLA3__23 STUB_BLB0_20 STUB_BLB0_21 STUB_BLB0_22
+  STUB_BLB0_23 STUB_BLB0__20 STUB_BLB0__21 STUB_BLB0__22 STUB_BLB0__23
+  STUB_BLB1_20 STUB_BLB1_21 STUB_BLB1_22 STUB_BLB1_23 STUB_BLB1__20
+  STUB_BLB1__21 STUB_BLB1__22 STUB_BLB1__23 STUB_BLB2_20 STUB_BLB2_21
+  STUB_BLB2_22 STUB_BLB2_23 STUB_BLB2__20 STUB_BLB2__21 STUB_BLB2__22
+  STUB_BLB2__23 STUB_BLB3_20 STUB_BLB3_21 STUB_BLB3_22 STUB_BLB3_23
+  STUB_BLB3__20 STUB_BLB3__21 STUB_BLB3__22 STUB_BLB3__23 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI6_0 BWEIA_6 BWEIB_6 CRENA CRENA DNA_6 DNB_6 FIOBTPA FIOBTPB GDLA_24 GDLA_25
+  GDLA_26 GDLA_27 GDLA__24 GDLA__25 GDLA__26 GDLA__27 GDLB_24 GDLB_25 GDLB_26
+  GDLB_27 GDLB__24 GDLB__25 GDLB__26 GDLB__27 IOBTPA IOBTPB IRET ORET QA__6
+  QB__6 STUB_BLA0_24 STUB_BLA0_25 STUB_BLA0_26 STUB_BLA0_27 STUB_BLA0__24
+  STUB_BLA0__25 STUB_BLA0__26 STUB_BLA0__27 STUB_BLA1_24 STUB_BLA1_25
+  STUB_BLA1_26 STUB_BLA1_27 STUB_BLA1__24 STUB_BLA1__25 STUB_BLA1__26
+  STUB_BLA1__27 STUB_BLA2_24 STUB_BLA2_25 STUB_BLA2_26 STUB_BLA2_27
+  STUB_BLA2__24 STUB_BLA2__25 STUB_BLA2__26 STUB_BLA2__27 STUB_BLA3_24
+  STUB_BLA3_25 STUB_BLA3_26 STUB_BLA3_27 STUB_BLA3__24 STUB_BLA3__25
+  STUB_BLA3__26 STUB_BLA3__27 STUB_BLB0_24 STUB_BLB0_25 STUB_BLB0_26
+  STUB_BLB0_27 STUB_BLB0__24 STUB_BLB0__25 STUB_BLB0__26 STUB_BLB0__27
+  STUB_BLB1_24 STUB_BLB1_25 STUB_BLB1_26 STUB_BLB1_27 STUB_BLB1__24
+  STUB_BLB1__25 STUB_BLB1__26 STUB_BLB1__27 STUB_BLB2_24 STUB_BLB2_25
+  STUB_BLB2_26 STUB_BLB2_27 STUB_BLB2__24 STUB_BLB2__25 STUB_BLB2__26
+  STUB_BLB2__27 STUB_BLB3_24 STUB_BLB3_25 STUB_BLB3_26 STUB_BLB3_27
+  STUB_BLB3__24 STUB_BLB3__25 STUB_BLB3__26 STUB_BLB3__27 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI7_0 BWEIA_7 BWEIB_7 CRENA CRENA DNA_7 DNB_7 FIOBTPA FIOBTPB GDLA_28 GDLA_29
+  GDLA_30 GDLA_31 GDLA__28 GDLA__29 GDLA__30 GDLA__31 GDLB_28 GDLB_29 GDLB_30
+  GDLB_31 GDLB__28 GDLB__29 GDLB__30 GDLB__31 IOBTPA IOBTPB IRET ORET QA__7
+  QB__7 STUB_BLA0_28 STUB_BLA0_29 STUB_BLA0_30 STUB_BLA0_31 STUB_BLA0__28
+  STUB_BLA0__29 STUB_BLA0__30 STUB_BLA0__31 STUB_BLA1_28 STUB_BLA1_29
+  STUB_BLA1_30 STUB_BLA1_31 STUB_BLA1__28 STUB_BLA1__29 STUB_BLA1__30
+  STUB_BLA1__31 STUB_BLA2_28 STUB_BLA2_29 STUB_BLA2_30 STUB_BLA2_31
+  STUB_BLA2__28 STUB_BLA2__29 STUB_BLA2__30 STUB_BLA2__31 STUB_BLA3_28
+  STUB_BLA3_29 STUB_BLA3_30 STUB_BLA3_31 STUB_BLA3__28 STUB_BLA3__29
+  STUB_BLA3__30 STUB_BLA3__31 STUB_BLB0_28 STUB_BLB0_29 STUB_BLB0_30
+  STUB_BLB0_31 STUB_BLB0__28 STUB_BLB0__29 STUB_BLB0__30 STUB_BLB0__31
+  STUB_BLB1_28 STUB_BLB1_29 STUB_BLB1_30 STUB_BLB1_31 STUB_BLB1__28
+  STUB_BLB1__29 STUB_BLB1__30 STUB_BLB1__31 STUB_BLB2_28 STUB_BLB2_29
+  STUB_BLB2_30 STUB_BLB2_31 STUB_BLB2__28 STUB_BLB2__29 STUB_BLB2__30
+  STUB_BLB2__31 STUB_BLB3_28 STUB_BLB3_29 STUB_BLB3_30 STUB_BLB3_31
+  STUB_BLB3__28 STUB_BLB3__29 STUB_BLB3__30 STUB_BLB3__31 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
.ENDS pe_spad_1024x16_dpIO_ROW_L
****
.SUBCKT pe_spad_1024x16_dpAL AGTP AGTPN AI0N AI1N AI2N AI3N AI4N AI5N AI6N
+  AI7N AI8N AI9N AI10N AI11N AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12
+  AX0N AX1N AX2N AX3N AX4N AX5N AY0N AY1N AY2N AY2N_A AY2N_B AY3N AY3N_A
+  AY3N_B BS0N BS1N BS2N FIOGTPA FIOGTPB GWENA GWENB IOGTPNA IOGTPNB PRRA0N
+  PRRA1N RET RRA0 RRA0_ RRA1 RRA1_ RREN TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpAL: 178 flat devices **
M0 HNET116 PRRA0N VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I12/N02
M1 HNET117 NET518 HNET116 VSSE NCH W=3U L=0.06U M=1 $name=/I12/N01
M10 VDDPE NET518 NET318 VDDCE PCH W=2U L=0.06U M=1 $name=/I13/P10
M100 AO12 NET410 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/grrendrv/N00
M101 VDDPE NET410 AO12 VDDCE PCH W=9.99U L=0.06U M=1 $name=/grrendrv/P00
M102 RRA1 NET322 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/grradrv/N00
M103 VDDPE NET322 RRA1 VDDCE PCH W=6U L=0.06U M=1 $name=/grradrv/P00
M104 NET324 PRRA0N VSSE VSSE NCH W=0.65U L=0.06U M=1 $name=/grra1inv/N00
M105 VDDPE PRRA0N NET324 VDDCE PCH W=1.1U L=0.06U M=1 $name=/grra1inv/P00
M106 AI12 NET410 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/gbspdrv/N00
M107 VDDPE NET410 AI12 VDDCE PCH W=4.6U L=0.06U M=1 $name=/gbspdrv/P00
M108 BS2N AI12 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/gbsdrv/N00
M109 VDDPE AI12 BS2N VDDCE PCH W=12U L=0.06U M=1 $name=/gbsdrv/P00
M11 VDDPE NET498 NET318 VDDCE PCH W=2U L=0.06U M=1 $name=/I13/P00
M110 NET477 NET344 VSSE VSSE NCH W=1.44U L=0.06U M=1 $name=/gaypdrv/N00
M111 VDDPE NET344 NET477 VDDCE PCH W=2.45U L=0.06U M=1 $name=/gaypdrv/P00
M112 AY1N NET477 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/gaydrv/N00
M113 VDDPE NET477 AY1N VDDCE PCH W=6U L=0.06U M=1 $name=/gaydrv/P00
M114 NET479 NET422 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/gaxpdrv/N00
M115 VDDPE NET422 NET479 VDDCE PCH W=4.6U L=0.06U M=1 $name=/gaxpdrv/P00
M116 AX4N NET479 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/gaxdrv/N00
M117 VDDPE NET479 AX4N VDDCE PCH W=12U L=0.06U M=1 $name=/gaxdrv/P00
M118 NET518 PRRA1N VSSE VSSE NCH W=0.65U L=0.06U M=1 $name=/I8/N00
M119 VDDPE PRRA1N NET518 VDDCE PCH W=1.1U L=0.06U M=1 $name=/I8/P00
M12 HNET130 PRRA0N VSSE VSSE NCH W=3U L=0.06U M=1 $name=/grrend/N02
M120 NET520 AI2N VSSE VSSE NCH W=1.44U L=0.06U M=1 $name=/I68/N00
M121 VDDPE AI2N NET520 VDDCE PCH W=2.46U L=0.06U M=1 $name=/I68/P00
M122 AI10 NET467 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I6/N00
M123 VDDPE NET467 AI10 VDDCE PCH W=4.6U L=0.06U M=1 $name=/I6/P00
M124 NET524 AI3N VSSE VSSE NCH W=1.44U L=0.06U M=1 $name=/I53/N00
M125 VDDPE AI3N NET524 VDDCE PCH W=2.46U L=0.06U M=1 $name=/I53/P00
M126 AY0N AY0 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I51/N00
M127 VDDPE AY0 AY0N VDDCE PCH W=6U L=0.06U M=1 $name=/I51/P00
M128 AY0 AY0NLOUT VSSE VSSE NCH W=1.44U L=0.06U M=1 $name=/I46/N00
M129 VDDPE AY0NLOUT AY0 VDDCE PCH W=2.45U L=0.06U M=1 $name=/I46/P00
M13 HNET131 PRRA1N HNET130 VSSE NCH W=3U L=0.06U M=1 $name=/grrend/N01
M130 RRA1_ NET326 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I41/N00
M131 VDDPE NET326 RRA1_ VDDCE PCH W=6U L=0.06U M=1 $name=/I41/P00
M132 NET489 NET458 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I40/N00
M133 VDDPE NET458 NET489 VDDCE PCH W=4.6U L=0.06U M=1 $name=/I40/P00
M134 NET534 NET450 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I4/N00
M135 VDDPE NET450 NET534 VDDCE PCH W=4.6U L=0.06U M=1 $name=/I4/P00
M136 AI11 NET453 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I39/N00
M137 VDDPE NET453 AI11 VDDCE PCH W=4.6U L=0.06U M=1 $name=/I39/P00
M138 BS1N AI11 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/I38/N00
M139 VDDPE AI11 BS1N VDDCE PCH W=12U L=0.06U M=1 $name=/I38/P00
M14 NET322 NET498 HNET131 VSSE NCH W=3U L=0.06U M=1 $name=/grrend/N00
M140 AO4 NET455 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I37/N00
M141 VDDPE NET455 AO4 VDDCE PCH W=10U L=0.06U M=1 $name=/I37/P00
M142 AO5 NET429 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I36/N00
M143 VDDPE NET429 AO5 VDDCE PCH W=9.99U L=0.06U M=1 $name=/I36/P00
M144 AO6 NET458 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I35/N00
M145 VDDPE NET458 AO6 VDDCE PCH W=9.99U L=0.06U M=1 $name=/I35/P00
M146 AX0N NET487 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/I34/N00
M147 VDDPE NET487 AX0N VDDCE PCH W=12U L=0.06U M=1 $name=/I34/P00
M148 AO7 NET432 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I33/N00
M149 VDDPE NET432 AO7 VDDCE PCH W=9.99U L=0.06U M=1 $name=/I33/P00
M15 VDDPE PRRA0N NET322 VDDCE PCH W=2U L=0.06U M=1 $name=/grrend/P20
M150 AO8 NET422 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I31/N00
M151 VDDPE NET422 AO8 VDDCE PCH W=9.99U L=0.06U M=1 $name=/I31/P00
M152 AO9 NET450 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I30/N00
M153 VDDPE NET450 AO9 VDDCE PCH W=9.99U L=0.06U M=1 $name=/I30/P00
M154 AY2N NET520 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I3/N00
M155 VDDPE NET520 AY2N VDDCE PCH W=6U L=0.06U M=1 $name=/I3/P00
M156 NET487 NET455 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I28/N00
M157 VDDPE NET455 NET487 VDDCE PCH W=4.6U L=0.06U M=1 $name=/I28/P00
M158 AX2N NET489 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/I27/N00
M159 VDDPE NET489 AX2N VDDCE PCH W=12U L=0.06U M=1 $name=/I27/P00
M16 VDDPE PRRA1N NET322 VDDCE PCH W=2U L=0.06U M=1 $name=/grrend/P10
M160 AX1N NET566 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/I26/N00
M161 VDDPE NET566 AX1N VDDCE PCH W=12U L=0.06U M=1 $name=/I26/P00
M162 AO10 NET467 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I25/N00
M163 VDDPE NET467 AO10 VDDCE PCH W=9.99U L=0.06U M=1 $name=/I25/P00
M164 AO11 NET453 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I24/N00
M165 VDDPE NET453 AO11 VDDCE PCH W=9.99U L=0.06U M=1 $name=/I24/P00
M166 NET566 NET429 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I21/N00
M167 VDDPE NET429 NET566 VDDCE PCH W=4.6U L=0.06U M=1 $name=/I21/P00
M168 AY3N NET524 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I2/N00
M169 VDDPE NET524 AY3N VDDCE PCH W=6U L=0.06U M=1 $name=/I2/P00
M17 VDDPE NET498 NET322 VDDCE PCH W=2U L=0.06U M=1 $name=/grrend/P00
M170 AX3N NET572 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/I19/N00
M171 VDDPE NET572 AX3N VDDCE PCH W=12U L=0.06U M=1 $name=/I19/P00
M172 NET572 NET432 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I14/N00
M173 VDDPE NET432 NET572 VDDCE PCH W=4.6U L=0.06U M=1 $name=/I14/P00
M174 BS0N AI10 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/I11/N00
M175 VDDPE AI10 BS0N VDDCE PCH W=12U L=0.06U M=1 $name=/I11/P00
M176 AX5N NET534 VSSE VSSE NCH W=7U L=0.06U M=1 $name=/I10/N00
M177 VDDPE NET534 AX5N VDDCE PCH W=12U L=0.06U M=1 $name=/I10/P00
M18 HNET137 NET324 VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I42/N02
M19 HNET138 PRRA1N HNET137 VSSE NCH W=3U L=0.06U M=1 $name=/I42/N01
M2 NET314 NET498 HNET117 VSSE NCH W=3U L=0.06U M=1 $name=/I12/N00
M20 NET326 NET498 HNET138 VSSE NCH W=3U L=0.06U M=1 $name=/I42/N00
M21 VDDPE NET324 NET326 VDDCE PCH W=2U L=0.06U M=1 $name=/I42/P20
M22 VDDPE PRRA1N NET326 VDDCE PCH W=2U L=0.06U M=1 $name=/I42/P10
M23 VDDPE NET498 NET326 VDDCE PCH W=2U L=0.06U M=1 $name=/I42/P00
M24 VDDPE TIELO TIEHI VDDCE PCH W=0.75U L=0.06U M=1 $name=/P5/P00
M25 VDDPE TIEHI TIEHI VDDCE PCH W=0.15U L=0.06U M=1 $name=/P6/P00
M26 NET410 AGTP AI12N VDDCE PCH W=2.4U L=0.06U M=1 $name=/tpbspg/P00
M27 NET411 AGTPN NET410 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpbsfbpg/P00
M28 NET344 AGTP AI1N VDDCE PCH W=2.4U L=0.06U M=1 $name=/tpaypg/P00
M29 NET345 AGTPN NET344 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpayfbpg/P00
M3 VDDPE PRRA0N NET314 VDDCE PCH W=2U L=0.06U M=1 $name=/I12/P20
M30 NET422 AGTP AI8N VDDCE PCH W=2.4U L=0.06U M=1 $name=/tpaxpg/P00
M31 NET423 AGTPN NET422 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpaxfbpg/P00
M32 NET455 AGTP AI4N VDDCE PCH W=2.4U L=0.06U M=1 $name=/tpa4pg/P00
M33 NET429 AGTP AI5N VDDCE PCH W=2.4U L=0.06U M=1 $name=/P9/P00
M34 NET432 AGTP AI7N VDDCE PCH W=2.4U L=0.06U M=1 $name=/P8/P00
M35 NET363 AGTPN NET432 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P7/P00
M36 NET467 AGTP AI10N VDDCE PCH W=2.4U L=0.06U M=1 $name=/P4/P00
M37 NET369 AGTPN NET450 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P3/P00
M38 AY0NLOUT AGTP AI0N VDDCE PCH W=2.4U L=0.06U M=1 $name=/P24/P00
M39 NET447 AGTPN AY0NLOUT VDDCE PCH W=0.15U L=0.06U M=1 $name=/P23/P00
M4 VDDPE NET518 NET314 VDDCE PCH W=2U L=0.06U M=1 $name=/I12/P10
M40 NET450 AGTP AI9N VDDCE PCH W=2.4U L=0.06U M=1 $name=/P2/P00
M41 NET453 AGTP AI11N VDDCE PCH W=2.4U L=0.06U M=1 $name=/P15/P00
M42 NET456 AGTPN NET455 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P13/P00
M43 NET459 AGTPN NET458 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P12/P00
M44 NET458 AGTP AI6N VDDCE PCH W=2.4U L=0.06U M=1 $name=/P11/P00
M45 NET393 AGTPN NET429 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P10/P00
M46 NET468 AGTPN NET467 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P1/P00
M47 NET399 AGTPN NET453 VDDCE PCH W=0.15U L=0.06U M=1 $name=/P0/P00
M48 VSSE TIEHI TIELO VSSE NCH W=1.05U L=0.06U M=1 $name=/N5/N00
M49 VSSE TIELO TIELO VSSE NCH W=0.15U L=0.06U M=1 $name=/N6/N00
M5 VDDPE NET498 NET314 VDDCE PCH W=2U L=0.06U M=1 $name=/I12/P00
M50 NET410 AGTPN AI12N VSSE NCH W=2.4U L=0.06U M=1 $name=/tnbspg/N00
M51 NET411 AGTP NET410 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnbsfbpg/N00
M52 NET344 AGTPN AI1N VSSE NCH W=2.4U L=0.06U M=1 $name=/tnaypg/N00
M53 NET345 AGTP NET344 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnayfbpg/N00
M54 NET422 AGTPN AI8N VSSE NCH W=2.4U L=0.06U M=1 $name=/tnaxpg/N00
M55 NET423 AGTP NET422 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnaxfbpg/N00
M56 NET455 AGTPN AI4N VSSE NCH W=2.4U L=0.06U M=1 $name=/tna4pg/N00
M57 NET429 AGTPN AI5N VSSE NCH W=2.4U L=0.06U M=1 $name=/N9/N00
M58 NET432 AGTPN AI7N VSSE NCH W=2.4U L=0.06U M=1 $name=/N8/N00
M59 NET363 AGTP NET432 VSSE NCH W=0.15U L=0.06U M=1 $name=/N7/N00
M6 HNET123 NET324 VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I13/N02
M60 NET467 AGTPN AI10N VSSE NCH W=2.4U L=0.06U M=1 $name=/N4/N00
M61 NET369 AGTP NET450 VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M62 AY0NLOUT AGTPN AI0N VSSE NCH W=2.4U L=0.06U M=1 $name=/N24/N00
M63 NET447 AGTP AY0NLOUT VSSE NCH W=0.15U L=0.06U M=1 $name=/N23/N00
M64 NET450 AGTPN AI9N VSSE NCH W=2.4U L=0.06U M=1 $name=/N2/N00
M65 NET453 AGTPN AI11N VSSE NCH W=2.4U L=0.06U M=1 $name=/N15/N00
M66 NET456 AGTP NET455 VSSE NCH W=0.15U L=0.06U M=1 $name=/N13/N00
M67 NET459 AGTP NET458 VSSE NCH W=0.15U L=0.06U M=1 $name=/N12/N00
M68 NET458 AGTPN AI6N VSSE NCH W=2.4U L=0.06U M=1 $name=/N11/N00
M69 NET393 AGTP NET429 VSSE NCH W=0.15U L=0.06U M=1 $name=/N10/N00
M7 HNET124 NET518 HNET123 VSSE NCH W=3U L=0.06U M=1 $name=/I13/N01
M70 NET468 AGTP NET467 VSSE NCH W=0.15U L=0.06U M=1 $name=/N1/N00
M71 NET399 AGTP NET453 VSSE NCH W=0.15U L=0.06U M=1 $name=/N0/N00
M72 NET399 AI11 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gkeepinv/N00
M73 VDDPE AI11 NET399 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gkeepinv/P00
M74 NET411 AI12 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gbsfb/N00
M75 VDDPE AI12 NET411 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gbsfb/P00
M76 NET345 NET477 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gayfb/N00
M77 VDDPE NET477 NET345 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gayfb/P00
M78 NET423 NET479 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gaxfb/N00
M79 VDDPE NET479 NET423 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gaxfb/P00
M8 NET318 NET498 HNET124 VSSE NCH W=3U L=0.06U M=1 $name=/I13/N00
M80 NET369 NET534 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I7/N00
M81 VDDPE NET534 NET369 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I7/P00
M82 NET468 AI10 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I5/N00
M83 VDDPE AI10 NET468 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I5/P00
M84 NET447 AY0 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I47/N00
M85 VDDPE AY0 NET447 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I47/P00
M86 NET456 NET487 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I29/N00
M87 VDDPE NET487 NET456 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I29/P00
M88 NET459 NET489 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I22/N00
M89 VDDPE NET489 NET459 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I22/P00
M9 VDDPE NET324 NET318 VDDCE PCH W=2U L=0.06U M=1 $name=/I13/P20
M90 NET393 NET566 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I20/N00
M91 VDDPE NET566 NET393 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I20/P00
M92 NET363 NET572 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I15/N00
M93 VDDPE NET572 NET363 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/I15/P00
M94 RRA0_ NET318 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I18/N00
M95 VDDPE NET318 RRA0_ VDDCE PCH W=6U L=0.06U M=1 $name=/I18/P00
M96 RRA0 NET314 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/I17/N00
M97 VDDPE NET314 RRA0 VDDCE PCH W=6U L=0.06U M=1 $name=/I17/P00
M98 NET498 RREN VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/grreninv/N00
M99 VDDPE RREN NET498 VDDCE PCH W=4.46U L=0.06U M=1 $name=/grreninv/P00
.ENDS pe_spad_1024x16_dpAL
****
.SUBCKT pe_spad_1024x16_dpALX_L AGTP AGTPN AI0N AI1N AI2N AI3N AI4N AI5N AI6N
+  AI7N AI8N AI9N AI10N AI11N AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12
+  AX0N AX1N AX2N AX3N AX4N AX5N AY0N AY1N AY2N_A AY2N_B AY3N_A AY3N_B BS0N
+  BS1N BS2N FIOGTPA FIOGTPB GWENA GWENB IOGTPNA IOGTPNB PRRA0N PRRA1N RET
+  RRA0 RRA0_ RRA1 RRA1_ RREN TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpALX_L: 178 flat devices **
XI0_0 AGTP AGTPN AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N AI9N AI10N AI11N
+  AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12 AX0N AX1N AX2N AX3N AX4N AX5N
+  AY0N AY1N AY2N_A AY2N_A AY2N_B AY3N_A AY3N_A AY3N_B BS0N BS1N BS2N FIOGTPA
+  FIOGTPB GWENA GWENB IOGTPNA IOGTPNB PRRA0N PRRA1N RET RRA0 RRA0_ RRA1 RRA1_
+  RREN TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpAL
.ENDS pe_spad_1024x16_dpALX_L
****
.SUBCKT pe_spad_1024x16_dpCTRL AGTP AGTPN AY2N_A AY2N_B AY3N_A AY3N_B BS0N
+  BS1N BS2N CEI CLK EMA0 EMA1 EMA2 FIOBTPA FIOBTPB FIOGTP FIOGTPA FIOGTPB GTP
+  GTPDE GTPDS GWEI GWEN GWENA GWENB IOBTPA IOBTPB IOGTPN IOGTPNA IOGTPNB IRET
+  LGWE MBL MBLDLY MBLDLY1 MBLDLY2 MBLDLY3 MBLDLY4 MBLDLY5 MGDLE MGDLS MGTPS
+  ORET PRDT PWBT RDTN RET RREN STOV TERM_CRENA TERM_CRENB TERM_GDLA
+  TERM_GDLA_ TERM_GDLB TERM_GDLB_ TERM_WEIAJ TERM_WEIBJ TERM_YSNA TERM_YSNB
+  TIEHI TIELO WBT WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B
+  YP1_3_A YP1_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCTRL: 442 flat devices **
D0 VSSE EMA1 NDIO 5.76e-08U 0.96U $name=/D5
D1 VSSE EMA2 NDIO 5.76e-08U 0.96U $name=/D4
M10 HNET236 NET940 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I85/N01
M100 NET548 MBLDLY3 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I7/N00
M101 VDDPE MBLDLY3 NET548 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I7/P00
M102 NET550 MBLDLY4 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I9/N00
M103 VDDPE MBLDLY4 NET550 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I9/P00
M104 MBLDLY5 NET550 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I11/N00
M105 VDDPE NET550 MBLDLY5 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I11/P00
M106 NET554 GTP VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gtpsdrv2/N00
M107 VDDPE GTP NET554 VDDCE PCH_HVT W=0.5U L=0.06U M=1 $name=/gtpsdrv2/P00
M108 NET689 RGWE VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gwefb2/N00
M109 VDDPE RGWE NET689 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gwefb2/P00
M11 NET947 NET936 HNET236 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I85/N00
M110 NET746 NET869 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gwefb1/N00
M111 VDDPE NET869 NET746 VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/gwefb1/P00
M112 NET699 TIELO VSSE VSSE NCH_HVT W=0.66U L=0.06U M=1 $name=/gtielo/N00
M113 VDDPE TIELO NET699 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gtielo/P00
M114 STOVB STOVI VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gstovsel/N00
M115 VDDPE STOVI STOVB VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/gstovsel/P00
M116 MBLDLY4 NET548 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I10/N00
M117 VDDPE NET548 MBLDLY4 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I10/P00
M118 LONGEMA NET567 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/glongd4/N00
M119 VDDPE NET567 LONGEMA VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/glongd4/P00
M12 VDDPE NET940 NET947 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I85/P10
M120 EMA00 EMA00B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gselinv/N00
M121 VDDPE EMA00B EMA00 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/gselinv/P00
M122 NET570 PRDT VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/grdt/N00
M123 VDDPE PRDT NET570 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/grdt/P00
M124 MBLSELN MBLSEL VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gmblsel0/N00
M125 VDDPE MBLSEL MBLSELN VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gmblsel0/P00
M126 NET574 NET575 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gmbln2/N00
M127 VDDPE NET575 NET574 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/gmbln2/P00
M128 NET499 NET577 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/glongd1/N00
M129 VDDPE NET577 NET499 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/glongd1/P00
M13 VDDPE NET936 NET947 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I85/P00
M130 EMA1N EMA1 VSSE VSSE NCH_HVT W=0.66U L=0.06U M=1 $name=/gema1/N00
M131 VDDPE EMA1 EMA1N VDDCE PCH_HVT W=1.5U L=0.06U M=1 $name=/gema1/P00
M132 NET580 NET504 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gdorfinv/N00
M133 VDDPE NET504 NET580 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/gdorfinv/P00
M134 NET472 NET583 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/gdlyinv2/N00
M135 VDDPE NET583 NET472 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/gdlyinv2/P00
M136 NET508 NET585 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/gdlyinv1/N00
M137 VDDPE NET585 NET508 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/gdlyinv1/P00
M138 NET815 NET471 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/gdlyinv3/N00
M139 VDDPE NET471 NET815 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/gdlyinv3/P00
M14 HNET241 NET936 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I86/N01
M140 NET990 NET513 VSSE VSSE NCH_HVT W=0.5U L=0.06U M=1 $name=/gdlyinv0/N00
M141 VDDPE NET513 NET990 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/gdlyinv0/P00
M142 EMA10 EMA10B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I93/N00
M143 VDDPE EMA10B EMA10 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I93/P00
M144 EMA11 EMA11B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I92/N00
M145 VDDPE EMA11B EMA11 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I92/P00
M146 NET511 STOV VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I89/N00
M147 VDDPE STOV NET511 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I89/P00
M148 EMA2N EMA2 VSSE VSSE NCH_HVT W=0.23U L=0.06U M=1 $name=/gema2/N00
M149 VDDPE EMA2 EMA2N VDDCE PCH_HVT W=0.54U L=0.06U M=1 $name=/gema2/P00
M15 NET480 NET938 HNET241 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I86/N00
M150 NET598 NET554 VSSE VSSE NCH_HVT W=0.7U L=0.06U M=1 $name=/gtpsinv1/N00
M151 VDDPE NET554 NET598 VDDCE PCH_HVT W=1.2U L=0.06U M=1 $name=/gtpsinv1/P00
M152 NET547 MBLDLY2 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I1/N00
M153 VDDPE MBLDLY2 NET547 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I1/P00
M154 EMA0N EMA0 VSSE VSSE NCH_HVT W=0.7U L=0.06U M=1 $name=/gema0/N00
M155 VDDPE EMA0 EMA0N VDDCE PCH_HVT W=1.62U L=0.06U M=1 $name=/gema0/P00
M156 EMA01 EMA01B VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I91/N00
M157 VDDPE EMA01B EMA01 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I91/P00
M158 NET760 NET796 VSSE VSSE NCH W=0.6U L=0.12U M=1 $name=/N38/N00
M159 NET613 RSTGTP VSSE VSSE NCH W=2.76U L=0.06U M=1 $name=/N37/N00
M16 VDDPE NET936 NET480 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I86/P10
M160 GTP SETGTP NET613 VSSE NCH W=2.76U L=0.06U M=1 $name=/N33/N00
M161 EMAPRE EMA10 NET472 VSSE NCH W=0.2U L=0.06U M=1 $name=/N27/N00
M162 GTP IRET VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N2/N00
M163 NET623 RSTGTP VSSE VSSE NCH W=2.76U L=0.06U M=1 $name=/N1/N00
M164 GTP SETGTP NET623 VSSE NCH W=2.76U L=0.06U M=1 $name=/N0/N00
M165 GTP SETGTP NET656 VSSE NCH W=2.76U L=0.06U M=1 $name=/tngtpdrv/N00
M166 EMAPRE EMA01 NET508 VSSE NCH W=0.2U L=0.06U M=1 $name=/N24/N00
M167 NET769 RGWEN GTPDE VSSE NCH W=0.3U L=0.06U M=1 $name=/N42/N00
M168 GTP SETGTP NET637 VSSE NCH W=2.76U L=0.06U M=1 $name=/N41/N00
M169 NET637 RSTGTP VSSE VSSE NCH W=2.76U L=0.06U M=1 $name=/N40/N00
M17 VDDPE NET938 NET480 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I86/P00
M170 GTP SETGTP NET643 VSSE NCH W=2.76U L=0.06U M=1 $name=/N4/N00
M171 NET643 RSTGTP VSSE VSSE NCH W=2.76U L=0.06U M=1 $name=/N7/N00
M172 GTP SETGTP NET677 VSSE NCH W=2.76U L=0.06U M=1 $name=/N5/N00
M173 GTPDS IRET VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tngtpdrst/N00
M174 NET656 RSTGTP VSSE VSSE NCH W=2.76U L=0.06U M=1 $name=/N6/N00
M175 NET769 RGWE GTPDS VSSE NCH W=0.3U L=0.06U M=1 $name=/tngtpdpg/N00
M176 MSI GTP VSSE VSSE NCH W=1.54U L=0.06U M=1 $name=/tngtp3b/N00
M177 NET757 MBLSEL MBLN VSSE NCH W=1U L=0.06U M=1 $name=/tnepg/N00
M178 EMAPRE EMA00 NET990 VSSE NCH W=0.2U L=0.06U M=1 $name=/tndlypg/N00
M179 SETGTP A CLKB VSSE NCH W=4.28U L=0.06U M=1 $name=/tnclkb/N00
M18 HNET246 NET932 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I35/N01
M180 NET674 NET674 VSSE VSSE NCH W=0.46U L=0.06U M=1 $name=/N9/N00
M181 NET677 RSTGTP VSSE VSSE NCH W=2.76U L=0.06U M=1 $name=/N8/N00
M182 MGDLE NET699 NET754 VSSE NCH W=1U L=0.06U M=1 $name=/N12/N00
M183 NET737 AGTP NET869 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnwepg2/N00
M184 NET740 AGTPN IWE VSSE NCH W=0.38U L=0.06U M=1 $name=/tnwepg1/N00
M185 NET689 AGTPN NET737 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnwefbpg2/N00
M186 NET746 AGTP NET740 VSSE NCH W=0.15U L=0.06U M=1 $name=/tnwefbpg1/N00
M187 STOVREMA STOVI NET749 VSSE NCH W=0.3U L=0.06U M=1 $name=/tnsepg/N00
M188 NET674 NET696 VSSE VSSE NCH W=0.45U L=0.06U M=1 $name=/tnplo/N00
M189 NET754 NET699 NET961 VSSE NCH W=10U L=0.06U M=1 $name=/tnmgdle/N00
M19 NET935 NET930 HNET246 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I35/N00
M190 NET757 MBLSELN NET534 VSSE NCH W=0.7U L=0.06U M=1 $name=/tnmblselpg/N00
M191 VSSE NET696 TIELO VSSE NCH W=4.96U L=0.06U M=1 $name=/tnlo/N00
M192 VSSE NET796 VSSE VSSE NCH W=0.6U L=0.12U M=1 $name=/tniogtp4/N00
M193 NET796 NET769 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tniogtp3/N00
M194 VSSE RET IOBTPB VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N14/N00
M195 VSSE RET FIOBTPA VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N3/N00
M196 VSSE RET IOBTPA VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N13/N00
M197 VSSE RET FIOBTPB VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N11/N00
M198 STOVREMA STOVB NET812 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/tnstovpg/N00
M199 EMAPRE EMA11 NET815 VSSE NCH_HVT W=0.2U L=0.06U M=1 $name=/N28/N00
M2 HNET226 NET472 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd3/N01
M20 VDDPE NET932 NET935 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I35/P10
M200 NET754 TIELO MGDLE VDDCE PCH W=1U L=0.06U M=1 $name=/P3/P00
M201 NET737 AGTPN NET869 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpwepg2/P00
M202 NET740 AGTP IWE VDDCE PCH W=0.38U L=0.06U M=1 $name=/tpwepg1/P00
M203 NET689 AGTP NET737 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpwefbpg2/P00
M204 NET746 AGTPN NET740 VDDCE PCH W=0.15U L=0.06U M=1 $name=/tpwefbpg1/P00
M205 NET749 STOVB STOVREMA VDDCE PCH W=0.3U L=0.06U M=1 $name=/tpsepg/P00
M206 VDDPE NET674 NET696 VDDCE PCH W=1.26U L=0.06U M=1 $name=/tpphi/P00
M207 NET961 TIELO NET754 VDDCE PCH W=10U L=0.06U M=1 $name=/tpmgdle/P00
M208 NET534 MBLSEL NET757 VDDCE PCH W=1U L=0.06U M=1 $name=/tpmblselpg/P00
M209 VDDPE NET796 NET760 VDDCE PCH W=1.02U L=0.06U M=1 $name=/tpiogtp4/P00
M21 VDDPE NET930 NET935 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I35/P00
M210 VDDPE TIELO TIEHI VDDCE PCH W=6.16U L=0.06U M=1 $name=/tphi/P00
M211 VDDPE SETGTP GTP VDDCE PCH W=14.1U L=0.06U M=1 $name=/tpgtpdrv/P00
M212 GTPDS RGWEN NET769 VDDCE PCH W=0.3U L=0.06U M=1 $name=/tpgtpdpg/P00
M213 VDDPE GTP VDDPE VDDCE PCH W=0.98U L=0.06U M=1 $name=/tpgtp3t/P00
M214 VDDPE GTP MSI VDDCE PCH W=0.98U L=0.06U M=1 $name=/tpgtp3m/P00
M215 VDDPE RSTGTP GTP VDDCE PCH W=14.1U L=0.06U M=1 $name=/tpgpdrv2/P00
M216 MBLN MBLSELN NET757 VDDCE PCH W=2U L=0.06U M=1 $name=/tpepg/P00
M217 NET990 EMA00B EMAPRE VDDCE PCH W=0.3U L=0.06U M=1 $name=/tpdlypg/P00
M218 VDDPE PREN_CTRLMBL MBL VDDCE PCH W=1.5U L=0.06U M=1 $name=/tkpmbl/P00
M219 VDDPE A SETGTP VDDCE PCH W=8.3U L=0.06U M=1 $name=/tgtpset/P00
M22 HNET251 NET930 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I31/N01
M220 VDDPE CKI SETGTP VDDCE PCH W=1.89U L=0.06U M=1 $name=/tgtpen/P00
M221 VDDPE NET769 NET796 VDDCE PCH W=0.52U L=0.12U M=1 $name=/P32/P00
M222 NET472 EMA10B EMAPRE VDDCE PCH W=0.3U L=0.06U M=1 $name=/P28/P00
M223 NET508 EMA01B EMAPRE VDDCE PCH W=0.3U L=0.06U M=1 $name=/P25/P00
M224 GTPDE RGWE NET769 VDDCE PCH W=0.3U L=0.06U M=1 $name=/P23/P00
M225 VDDPE NET696 NET696 VDDCE PCH W=0.45U L=0.06U M=1 $name=/P1/P00
M226 NET812 STOVI STOVREMA VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/tpstovpg/P00
M227 NET815 EMA11B EMAPRE VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/P29/P00
M228 NET816 RET VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/goretnor/N10
M229 NET816 NET818 VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/goretnor/N00
M23 NET929 NET830 HNET251 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I31/N00
M230 VDDCE RET HNET609 VDDCE PCH W=2.4U L=0.06U M=1 $name=/goretnor/P01
M231 HNET609 NET818 NET816 VDDCE PCH W=2.4U L=0.06U M=1 $name=/goretnor/P00
M232 AB IRET VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/gabdrv/N10
M233 AB CLKCE VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/gabdrv/N00
M234 VDDPE IRET HNET613 VDDCE PCH W=1U L=0.06U M=1 $name=/gabdrv/P01
M235 HNET613 CLKCE AB VDDCE PCH W=1U L=0.06U M=1 $name=/gabdrv/P00
M236 RDTN NET824 VSSE VSSE NCH W=2.32U L=0.06U M=1 $name=/grdtdrv/N00
M237 VDDPE NET824 RDTN VDDCE PCH W=4.6U L=0.06U M=1 $name=/grdtdrv/P00
M238 NET824 NET922 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/grdtb/N00
M239 VDDPE NET922 NET824 VDDCE PCH W=1.96U L=0.06U M=1 $name=/grdtb/P00
M24 VDDPE NET930 NET929 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I31/P10
M240 YP1_3_A NET489 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I26/N00
M241 VDDPE NET489 YP1_3_A VDDCE PCH W=8U L=0.06U M=1 $name=/I26/P00
M242 WEA GWENA VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I38/N00
M243 VDDPE GWENA WEA VDDCE PCH W=4.2U L=0.06U M=1 $name=/I38/P00
M244 NET830 NET932 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/gay0inv2/N00
M245 VDDPE NET932 NET830 VDDCE PCH W=3.4U L=0.06U M=1 $name=/gay0inv2/P00
M246 NET832 AY3N_A VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/I37/N00
M247 VDDPE AY3N_A NET832 VDDCE PCH W=3.4U L=0.06U M=1 $name=/I37/P00
M248 FIOBTPB NET844 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I39/N00
M249 VDDPE NET844 FIOBTPB VDDCE PCH W=9.5U L=0.06U M=1 $name=/I39/P00
M25 VDDPE NET830 NET929 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I31/P00
M250 NET836 FIOGTPA VSSE VSSE NCH W=2.1U L=0.06U M=1 $name=/gfiobtppdrv/N00
M251 VDDPE FIOGTPA NET836 VDDCE PCH W=3.6U L=0.06U M=1 $name=/gfiobtppdrv/P00
M252 FIOBTPA NET836 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/gfiobtpdrv/N00
M253 VDDPE NET836 FIOBTPA VDDCE PCH W=9.5U L=0.06U M=1 $name=/gfiobtpdrv/P00
M254 NET857 IOGTPNA VSSE VSSE NCH W=1.3U L=0.06U M=1 $name=/I45/N00
M255 VDDPE IOGTPNA NET857 VDDCE PCH W=2.2U L=0.06U M=1 $name=/I45/P00
M256 NET842 IOGTPNB VSSE VSSE NCH W=1.3U L=0.06U M=1 $name=/I53/N00
M257 VDDPE IOGTPNB NET842 VDDCE PCH W=2.2U L=0.06U M=1 $name=/I53/P00
M258 NET844 FIOGTPB VSSE VSSE NCH W=2.1U L=0.06U M=1 $name=/I40/N00
M259 VDDPE FIOGTPB NET844 VDDCE PCH W=3.6U L=0.06U M=1 $name=/I40/P00
M26 HNET256 NET932 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I33/N01
M260 NET846 NET961 VSSE VSSE NCH W=1.3U L=0.06U M=1 $name=/invmgdleb/N00
M261 VDDPE NET961 NET846 VDDCE PCH W=2.6U L=0.06U M=1 $name=/invmgdleb/P00
M262 NET848 NET842 VSSE VSSE NCH W=3.3U L=0.06U M=1 $name=/I50/N00
M263 VDDPE NET842 NET848 VDDCE PCH W=2.8U L=0.06U M=1 $name=/I50/P00
M264 MGDLS MSI VSSE VSSE NCH W=4U L=0.06U M=1 $name=/gmgdldrv/N00
M265 VDDPE MSI MGDLS VDDCE PCH W=6.8U L=0.06U M=1 $name=/gmgdldrv/P00
M266 IOBTPB NET848 VSSE VSSE NCH W=8.9U L=0.06U M=1 $name=/I49/N00
M267 VDDPE NET848 IOBTPB VDDCE PCH W=14U L=0.06U M=1 $name=/I49/P00
M268 IOBTPA NET855 VSSE VSSE NCH W=8.9U L=0.06U M=1 $name=/I46/N00
M269 VDDPE NET855 IOBTPA VDDCE PCH W=14U L=0.06U M=1 $name=/I46/P00
M27 NET489 NET832 HNET256 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I33/N00
M270 NET855 NET857 VSSE VSSE NCH W=3.3U L=0.06U M=1 $name=/I6/N00
M271 VDDPE NET857 NET855 VDDCE PCH W=2.8U L=0.06U M=1 $name=/I6/P00
M272 NET858 NET868 VSSE VSSE NCH W=1.74U L=0.06U M=1 $name=/glgwepdrv/N00
M273 VDDPE NET868 NET858 VDDCE PCH W=3U L=0.06U M=1 $name=/glgwepdrv/P00
M274 RETNDD RET VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tretdd/N00
M275 VDDCE RET RETNDD VDDCE PCH W=1.7U L=0.06U M=1 $name=/tretdd/P00
M276 MBLN MBLDLY VSSE VSSE NCH W=0.68U L=0.06U M=1 $name=/tmblndrv/N00
M277 VDDPE MBLDLY MBLN VDDCE PCH W=1.56U L=0.06U M=1 $name=/tmblndrv/P00
M278 RGWE NET737 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/gwelat2/N00
M279 VDDPE NET737 RGWE VDDCE PCH W=0.6U L=0.06U M=1 $name=/gwelat2/P00
M28 VDDPE NET932 NET489 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I33/P10
M280 NET869 NET740 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/gwelat1/N00
M281 VDDPE NET740 NET869 VDDCE PCH W=0.8U L=0.06U M=1 $name=/gwelat1/P00
M282 NET868 NET869 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/gweinv/N00
M283 VDDPE NET869 NET868 VDDCE PCH W=1.2U L=0.06U M=1 $name=/gweinv/P00
M284 WBT NET872 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gwbtdrv/N00
M285 VDDCE NET872 WBT VDDCE PCH W=0.3U L=0.06U M=1 $name=/gwbtdrv/P00
M286 NET872 PWBT VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gwbtb/N00
M287 VDDCE PWBT NET872 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gwbtb/P00
M288 NET874 NET598 VSSE VSSE NCH W=1.74U L=0.06U M=1 $name=/gtpsinv2/N00
M289 VDDPE NET598 NET874 VDDCE PCH W=3U L=0.06U M=1 $name=/gtpsinv2/P00
M29 VDDPE NET832 NET489 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I33/P00
M290 MGTPS NET874 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/gtpsdrv1/N00
M291 VDDPE NET874 MGTPS VDDCE PCH W=6.8U L=0.06U M=1 $name=/gtpsdrv1/P00
M292 PREN_CTRLMBL NET966 VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/gtlond/N00
M293 VDDPE NET966 PREN_CTRLMBL VDDCE PCH W=3U L=0.06U M=1 $name=/gtlond/P00
M294 NET966 GTP VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/gtlonb/N00
M295 VDDPE GTP NET966 VDDCE PCH W=1.02U L=0.06U M=1 $name=/gtlonb/P00
M296 RGWEN RGWE VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/grgwe/N00
M297 VDDPE RGWE RGWEN VDDCE PCH W=0.5U L=0.06U M=1 $name=/grgwe/P00
M298 IRET RETNDD VSSE VSSE NCH W=2.4U L=0.06U M=1 $name=/gretdrv/N00
M299 VDDCE RETNDD IRET VDDCE PCH W=4.08U L=0.06U M=1 $name=/gretdrv/P00
M3 NET471 PREN_CTRLMBL HNET226 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd3/N00
M30 HNET261 NET832 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I34/N01
M300 LGWE NET858 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/glgwedrv/N00
M301 VDDPE NET858 LGWE VDDCE PCH W=6.8U L=0.06U M=1 $name=/glgwedrv/P00
M302 NET888 NET816 VSSE VSSE NCH W=1.4U L=0.06U M=1 $name=/giretnd/N00
M303 VDDCE NET816 NET888 VDDCE PCH W=2.4U L=0.06U M=1 $name=/giretnd/P00
M304 NET890 NET1004 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnpdrv/N00
M305 VDDPE NET1004 NET890 VDDCE PCH W=0.5U L=0.06U M=1 $name=/giogtpnpdrv/P00
M306 IOGTPN NET890 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/giogtpndrv/N00
M307 VDDPE NET890 IOGTPN VDDCE PCH W=1U L=0.06U M=1 $name=/giogtpndrv/P00
M308 IWE NET896 VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/ggwenpdrv2/N00
M309 VDDPE NET896 IWE VDDCE PCH W=1.2U L=0.06U M=1 $name=/ggwenpdrv2/P00
M31 NET492 NET830 HNET261 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I34/N00
M310 NET896 GWEI VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/ggwenpdrv1/N00
M311 VDDPE GWEI NET896 VDDCE PCH W=0.6U L=0.06U M=1 $name=/ggwenpdrv1/P00
M312 GWEN IWE VSSE VSSE NCH W=2U L=0.06U M=1 $name=/ggwendrv/N00
M313 VDDPE IWE GWEN VDDCE PCH W=3.4U L=0.06U M=1 $name=/ggwendrv/P00
M314 GTPNDDW NET901 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/ggtpnddwdrv/N00
M315 VDDPE NET901 GTPNDDW VDDCE PCH W=0.85U L=0.06U M=1 $name=/ggtpnddwdrv/P00
M316 NET907 NET965 VSSE VSSE NCH W=1.74U L=0.06U M=1 $name=/ggtpdpdrv/N00
M317 VDDPE NET965 NET907 VDDCE PCH W=2.6U L=0.06U M=1 $name=/ggtpdpdrv/P00
M318 NET901 RSTGTP VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/ggtpddwdrv/N00
M319 VDDPE RSTGTP NET901 VDDCE PCH W=0.34U L=0.06U M=1 $name=/ggtpddwdrv/P00
M32 VDDPE NET832 NET492 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I34/P10
M320 GTPDS NET907 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/ggtpddrv/N00
M321 VDDPE NET907 GTPDS VDDCE PCH W=6.8U L=0.06U M=1 $name=/ggtpddrv/P00
M322 A NET968 VSSE VSSE NCH W=1.5U L=0.06U M=1 $name=/ggset3/N00
M323 VDDPE NET968 A VDDCE PCH W=3.06U L=0.06U M=1 $name=/ggset3/P00
M324 NET910 NET912 VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/ggset2/N00
M325 VDDPE NET912 NET910 VDDCE PCH W=1.2U L=0.06U M=1 $name=/ggset2/P00
M326 NET912 NET968 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/ggset/N00
M327 VDDPE NET968 NET912 VDDCE PCH W=0.5U L=0.06U M=1 $name=/ggset/P00
M328 FIOGTP NET979 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/gfiogtpdrv/N00
M329 VDDPE NET979 FIOGTP VDDCE PCH W=1.4U L=0.06U M=1 $name=/gfiogtpdrv/P00
M33 VDDPE NET830 NET492 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I34/P00
M330 CLKB CLK VSSE VSSE NCH W=8.4U L=0.06U M=1 $name=/gclk/N00
M331 VDDPE CLK CLKB VDDCE PCH W=11U L=0.06U M=1 $name=/gclk/P00
M332 CKI NET977 VSSE VSSE NCH W=0.27U L=0.06U M=1 $name=/gckidrv/N00
M333 VDDCE NET977 CKI VDDCE PCH W=0.54U L=0.06U M=1 $name=/gckidrv/P00
M334 AGTPN AGTP VSSE VSSE NCH W=1.97U L=0.06U M=1 $name=/gaptdrvb/N00
M335 VDDPE AGTP AGTPN VDDCE PCH W=3.35U L=0.06U M=1 $name=/gaptdrvb/P00
M336 NET922 PRDT VSSE VSSE NCH W=0.42U L=0.06U M=1 $name=/grdtinv/N00
M337 VDDPE PRDT NET922 VDDCE PCH W=0.84U L=0.06U M=1 $name=/grdtinv/P00
M338 NET924 AY3N_B VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/I14/N00
M339 VDDPE AY3N_B NET924 VDDCE PCH W=3.4U L=0.06U M=1 $name=/I14/P00
M34 HNET266 EMA0N VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gselnd/N01
M340 YP1_2_A NET492 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I28/N00
M341 VDDPE NET492 YP1_2_A VDDCE PCH W=8U L=0.06U M=1 $name=/I28/P00
M342 YP1_0_A NET929 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I25/N00
M343 VDDPE NET929 YP1_0_A VDDCE PCH W=8U L=0.06U M=1 $name=/I25/P00
M344 NET930 NET832 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I36/N00
M345 VDDPE NET832 NET930 VDDCE PCH W=3.4U L=0.06U M=1 $name=/I36/P00
M346 NET932 AY2N_A VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/gay0inv1/N00
M347 VDDPE AY2N_A NET932 VDDCE PCH W=3.4U L=0.06U M=1 $name=/gay0inv1/P00
M348 YP1_1_A NET935 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I30/N00
M349 VDDPE NET935 YP1_1_A VDDCE PCH W=8U L=0.06U M=1 $name=/I30/P00
M35 EMA00B EMA1N HNET266 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gselnd/N00
M350 NET936 NET924 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I15/N00
M351 VDDPE NET924 NET936 VDDCE PCH W=3.4U L=0.06U M=1 $name=/I15/P00
M352 NET938 NET940 VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I13/N00
M353 VDDPE NET940 NET938 VDDCE PCH W=3.4U L=0.06U M=1 $name=/I13/P00
M354 NET940 AY2N_B VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/I16/N00
M355 VDDPE AY2N_B NET940 VDDCE PCH W=3.4U L=0.06U M=1 $name=/I16/P00
M356 YP1_3_B NET474 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I18/N00
M357 VDDPE NET474 YP1_3_B VDDCE PCH W=8U L=0.06U M=1 $name=/I18/P00
M358 YP1_2_B NET528 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I19/N00
M359 VDDPE NET528 YP1_2_B VDDCE PCH W=8U L=0.06U M=1 $name=/I19/P00
M36 VDDPE EMA0N EMA00B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gselnd/P10
M360 YP1_1_B NET947 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I17/N00
M361 VDDPE NET947 YP1_1_B VDDCE PCH W=8U L=0.06U M=1 $name=/I17/P00
M362 NET953 NET888 VSSE VSSE NCH W=4U L=0.06U M=1 $name=/goretpdrv/N00
M363 VDDCE NET888 NET953 VDDCE PCH W=6.8U L=0.06U M=1 $name=/goretpdrv/P00
M364 YP1_0_B NET480 VSSE VSSE NCH W=5.5U L=0.06U M=1 $name=/I24/N00
M365 VDDPE NET480 YP1_0_B VDDCE PCH W=8U L=0.06U M=1 $name=/I24/P00
M366 ORET NET953 VSSE VSSE NCH W=14U L=0.06U M=1 $name=/goretdrv/N00
M367 VDDCE NET953 ORET VDDCE PCH W=24.44U L=0.06U M=1 $name=/goretdrv/P00
M368 NET954 NET757 VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/gmblseln3/N00
M369 VDDPE NET757 NET954 VDDCE PCH W=0.85U L=0.06U M=1 $name=/gmblseln3/P00
M37 VDDPE EMA1N EMA00B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gselnd/P00
M370 WEB GWENB VSSE VSSE NCH W=2U L=0.06U M=1 $name=/I77/N00
M371 VDDPE GWENB WEB VDDCE PCH W=4.2U L=0.06U M=1 $name=/I77/P00
M372 HNET755 PREN_CTRLMBL VSSE VSSE NCH W=0.7U L=0.06U M=1 $name=/gsend/N01
M373 NET749 CLKB HNET755 VSSE NCH W=0.7U L=0.06U M=1 $name=/gsend/N00
M374 VDDPE PREN_CTRLMBL NET749 VDDCE PCH W=0.5U L=0.06U M=1 $name=/gsend/P10
M375 VDDPE CLKB NET749 VDDCE PCH W=0.5U L=0.06U M=1 $name=/gsend/P00
M376 HNET759 RGWEN VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/gmgdlnd/N01
M377 NET964 NET961 HNET759 VSSE NCH W=1.1U L=0.06U M=1 $name=/gmgdlnd/N00
M378 VDDPE RGWEN NET964 VDDCE PCH W=1.1U L=0.06U M=1 $name=/gmgdlnd/P10
M379 VDDPE NET961 NET964 VDDCE PCH W=1.1U L=0.06U M=1 $name=/gmgdlnd/P00
M38 HNET271 NET499 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/glongd3/N01
M380 HNET763 NET966 VSSE VSSE NCH W=1.35U L=0.06U M=1 $name=/ggtpdnd/N01
M381 NET965 NET964 HNET763 VSSE NCH W=1.35U L=0.06U M=1 $name=/ggtpdnd/N00
M382 VDDPE NET966 NET965 VDDCE PCH W=1.35U L=0.06U M=1 $name=/ggtpdnd/P10
M383 VDDPE NET964 NET965 VDDCE PCH W=1.35U L=0.06U M=1 $name=/ggtpdnd/P00
M384 HNET767 AB VSSE VSSE NCH W=0.37U L=0.06U M=1 $name=/ggsetnd/N01
M385 NET968 GTPNDDW HNET767 VSSE NCH W=0.37U L=0.06U M=1 $name=/ggsetnd/N00
M386 VDDPE AB NET968 VDDCE PCH W=0.37U L=0.06U M=1 $name=/ggsetnd/P10
M387 VDDPE GTPNDDW NET968 VDDCE PCH W=0.37U L=0.06U M=1 $name=/ggsetnd/P00
M388 HNET771 GTP VSSE VSSE NCH W=1.47U L=0.06U M=1 $name=/gfiogtpnd/N01
M389 NET979 NET954 HNET771 VSSE NCH W=1.47U L=0.06U M=1 $name=/gfiogtpnd/N00
M39 NET567 PREN_CTRLMBL HNET271 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/glongd3/N00
M390 VDDPE GTP NET979 VDDCE PCH W=1.48U L=0.06U M=1 $name=/gfiogtpnd/P10
M391 VDDPE NET954 NET979 VDDCE PCH W=1.48U L=0.06U M=1 $name=/gfiogtpnd/P00
M392 HNET775 CLKB VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/gclkce/N01
M393 CLKCE CEI HNET775 VSSE NCH W=0.4U L=0.06U M=1 $name=/gclkce/N00
M394 VDDPE CLKB CLKCE VDDCE PCH W=0.4U L=0.06U M=1 $name=/gclkce/P10
M395 VDDPE CEI CLKCE VDDCE PCH W=0.4U L=0.06U M=1 $name=/gclkce/P00
M396 HNET779 CLK VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/gcknd/N01
M397 NET977 RETNDD HNET779 VSSE NCH W=0.3U L=0.06U M=1 $name=/gcknd/N00
M398 VDDCE CLK NET977 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gcknd/P10
M399 VDDCE RETNDD NET977 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gcknd/P00
M4 VDDPE NET472 NET471 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd3/P10
M40 VDDPE NET499 NET567 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/glongd3/P10
M400 HNET783 PREN_CTRLMBL VSSE VSSE NCH W=2U L=0.06U M=1 $name=/grstgtpw/N01
M401 NET980 NET979 HNET783 VSSE NCH W=2U L=0.06U M=1 $name=/grstgtpw/N00
M402 VDDPE PREN_CTRLMBL NET980 VDDCE PCH W=2U L=0.06U M=1 $name=/grstgtpw/P10
M403 VDDPE NET979 NET980 VDDCE PCH W=2U L=0.06U M=1 $name=/grstgtpw/P00
M404 HNET787 NET846 VSSE VSSE NCH W=1.98U L=0.06U M=1 $name=/gaptdrv/N01
M405 AGTP RSTGTP HNET787 VSSE NCH W=1.98U L=0.06U M=1 $name=/gaptdrv/N00
M406 VDDPE NET846 AGTP VDDCE PCH W=3.3U L=0.06U M=1 $name=/gaptdrv/P10
M407 VDDPE RSTGTP AGTP VDDCE PCH W=3.3U L=0.06U M=1 $name=/gaptdrv/P00
M408 MBLSEL NET580 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gmblsel1/N10
M409 MBLSEL STOVI VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gmblsel1/N00
M41 VDDPE PREN_CTRLMBL NET567 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/glongd3/P00
M410 VDDPE NET580 HNET789 VDDCE PCH_HVT W=0.6U L=0.06U M=1 $name=/gmblsel1/P01
M411 HNET789 STOVI MBLSEL VDDCE PCH_HVT W=0.6U L=0.06U M=1 $name=/gmblsel1/P00
M412 NET585 EMA2N VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gdlynr1/N10
M413 NET585 NET990 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gdlynr1/N00
M414 VDDPE EMA2N HNET793 VDDCE PCH_HVT W=0.6U L=0.06U M=1 $name=/gdlynr1/P01
M415 HNET793 NET990 NET585 VDDCE PCH_HVT W=0.6U L=0.06U M=1 $name=/gdlynr1/P00
M416 HNET801 EMA0N VSSE VSSE NCH_HVT W=0.45U L=0.06U M=1 $name=/gema000/N02
M417 HNET802 EMA1N HNET801 VSSE NCH_HVT W=0.45U L=0.06U M=1 $name=/gema000/N01
M418 EMA000N EMA2N HNET802 VSSE NCH_HVT W=0.45U L=0.06U M=1 $name=/gema000/N00
M419 VDDPE EMA0N EMA000N VDDCE PCH_HVT W=0.45U L=0.06U M=1 $name=/gema000/P20
M42 HNET276 NET502 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I136/N01
M420 VDDPE EMA1N EMA000N VDDCE PCH_HVT W=0.45U L=0.06U M=1 $name=/gema000/P10
M421 VDDPE EMA2N EMA000N VDDCE PCH_HVT W=0.45U L=0.06U M=1 $name=/gema000/P00
M422 HNET808 NET998 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/grettri2/NI00
M423 NET818 NET998 HNET808 VSSE NCH W=0.3U L=0.06U M=1 $name=/grettri2/NE00
M424 HNET803 NET998 NET818 VDDCE PCH W=0.3U L=0.06U M=1 $name=/grettri2/PE00
M425 VDDCE NET998 HNET803 VDDCE PCH W=0.3U L=0.06U M=1 $name=/grettri2/PI00
M426 HNET814 IRET VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/grettri1/NI00
M427 NET998 IRET HNET814 VSSE NCH W=0.3U L=0.06U M=1 $name=/grettri1/NE00
M428 HNET809 IRET NET998 VDDCE PCH W=0.3U L=0.06U M=1 $name=/grettri1/PE00
M429 VDDCE IRET HNET809 VDDCE PCH W=0.3U L=0.06U M=1 $name=/grettri1/PI00
M43 EMA11B NET500 HNET276 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I136/N00
M430 NET1004 NET760 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnnr/N20
M431 NET1004 GTPDS VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnnr/N10
M432 NET1004 GTP VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/giogtpnnr/N00
M433 VDDPE NET760 HNET820 VDDCE PCH W=1.8U L=0.06U M=1 $name=/giogtpnnr/P02
M434 HNET820 GTPDS HNET817 VDDCE PCH W=1.8U L=0.06U M=1 $name=/giogtpnnr/P01
M435 HNET817 GTP NET1004 VDDCE PCH W=1.8U L=0.06U M=1 $name=/giogtpnnr/P00
M436 HNET824 NET980 VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/ggtprsnd/N11
M437 RSTGTP GTP HNET824 VSSE NCH W=2.6U L=0.06U M=1 $name=/ggtprsnd/N10
M438 HNET822 NET980 VSSE VSSE NCH W=2.6U L=0.06U M=1 $name=/ggtprsnd/N01
M439 RSTGTP GTP HNET822 VSSE NCH W=2.6U L=0.06U M=1 $name=/ggtprsnd/N00
M44 VDDPE NET502 EMA11B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I136/P10
M440 VDDPE NET980 RSTGTP VDDCE PCH W=5.2U L=0.06U M=1 $name=/ggtprsnd/P10
M441 VDDPE GTP RSTGTP VDDCE PCH W=5.2U L=0.06U M=1 $name=/ggtprsnd/P00
M45 VDDPE NET500 EMA11B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I136/P00
M46 HNET281 EMA000N VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdorfnd/N01
M47 NET504 EMA000N HNET281 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdorfnd/N00
M48 VDDPE EMA000N NET504 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdorfnd/P10
M49 VDDPE EMA000N NET504 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdorfnd/P00
M5 VDDPE PREN_CTRLMBL NET471 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd3/P00
M50 HNET286 NET508 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd2/N01
M51 NET583 MBLN HNET286 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd2/N00
M52 VDDPE NET508 NET583 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd2/P10
M53 VDDPE MBLN NET583 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd2/P00
M54 HNET291 NET511 VSSE VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/gstovnd/N01
M55 STOVI NET570 HNET291 VSSE NCH_HVT W=0.44U L=0.06U M=1 $name=/gstovnd/N00
M56 VDDPE NET511 STOVI VDDCE PCH_HVT W=0.44U L=0.06U M=1 $name=/gstovnd/P10
M57 VDDPE NET570 STOVI VDDCE PCH_HVT W=0.44U L=0.06U M=1 $name=/gstovnd/P00
M58 HNET296 LONGEMA VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd0/N01
M59 NET513 PREN_CTRLMBL HNET296 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd0/N00
M6 HNET231 NET940 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I87/N01
M60 VDDPE LONGEMA NET513 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd0/P10
M61 VDDPE PREN_CTRLMBL NET513 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/gdlynd0/P00
M62 HNET301 MBLN VSSE VSSE NCH_HVT W=0.7U L=0.06U M=1 $name=/gdlydrv0/N01
M63 NET812 EMAPRE HNET301 VSSE NCH_HVT W=0.7U L=0.06U M=1 $name=/gdlydrv0/N00
M64 VDDPE MBLN NET812 VDDCE PCH_HVT W=0.5U L=0.06U M=1 $name=/gdlydrv0/P10
M65 VDDPE EMAPRE NET812 VDDCE PCH_HVT W=0.5U L=0.06U M=1 $name=/gdlydrv0/P00
M66 HNET306 NET502 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I12/N01
M67 EMA01B EMA1N HNET306 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I12/N00
M68 VDDPE NET502 EMA01B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I12/P10
M69 VDDPE EMA1N EMA01B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I12/P00
M7 NET474 NET924 HNET231 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I87/N00
M70 HNET311 EMA0N VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I137/N01
M71 EMA10B NET500 HNET311 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/I137/N00
M72 VDDPE EMA0N EMA10B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I137/P10
M73 VDDPE NET500 EMA10B VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/I137/P00
M74 HNET316 NET574 VSSE VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/glongd0/N01
M75 NET577 PREN_CTRLMBL HNET316 VSSE NCH_HVT W=0.3U L=0.06U M=1 $name=/glongd0/N00
M76 VDDPE NET574 NET577 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/glongd0/P10
M77 VDDPE PREN_CTRLMBL NET577 VDDCE PCH_HVT W=0.3U L=0.06U M=1 $name=/glongd0/P00
M78 HNET321 NET924 VSSE VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I88/N01
M79 NET528 NET938 HNET321 VSSE NCH_HVT W=3.5U L=0.06U M=1 $name=/I88/N00
M8 VDDPE NET940 NET474 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I87/P10
M80 VDDPE NET924 NET528 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I88/P10
M81 VDDPE NET938 NET528 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I88/P00
M82 MBLDLY1 NET536 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I3/N00
M83 VDDPE NET536 MBLDLY1 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I3/P00
M84 NET575 MBLN VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gmbln1/N00
M85 VDDPE MBLN NET575 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/gmbln1/P00
M86 NET534 STOVREMA VSSE VSSE NCH_HVT W=0.76U L=0.06U M=1 $name=/gemadrv/N00
M87 VDDPE STOVREMA NET534 VDDCE PCH_HVT W=1U L=0.06U M=1 $name=/gemadrv/P00
M88 NET536 MBL VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I2/N00
M89 VDDPE MBL NET536 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I2/P00
M9 VDDPE NET924 NET474 VDDCE PCH_HVT W=3.5U L=0.06U M=1 $name=/I87/P00
M90 NET502 EMA0N VSSE VSSE NCH_HVT W=0.17U L=0.06U M=1 $name=/gsel0/N00
M91 VDDPE EMA0N NET502 VDDCE PCH_HVT W=0.39U L=0.06U M=1 $name=/gsel0/P00
M92 NET500 EMA1N VSSE VSSE NCH_HVT W=0.38U L=0.06U M=1 $name=/gsel1/N00
M93 VDDPE EMA1N NET500 VDDCE PCH_HVT W=0.88U L=0.06U M=1 $name=/gsel1/P00
M94 MBLDLY2 NET544 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I4/N00
M95 VDDPE NET544 MBLDLY2 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I4/P00
M96 NET544 MBLDLY1 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I5/N00
M97 VDDPE MBLDLY1 NET544 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I5/P00
M98 MBLDLY3 NET547 VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/I0/N00
M99 VDDPE NET547 MBLDLY3 VDDCE PCH_HVT W=0.34U L=0.06U M=1 $name=/I0/P00
.ENDS pe_spad_1024x16_dpCTRL
****
.SUBCKT pe_spad_1024x16_dpCTRLX_L AGTP AGTPN AY2N_A AY2N_B AY3N_A AY3N_B BS0N
+  BS1N BS2N CEI CLK EMA0 EMA1 EMA2 FIOBTPA FIOBTPB FIOGTPA FIOGTPB GTP GTPDE
+  GTPDS GWEI GWENA GWENB IOBTPA IOBTPB IOGTPNA IOGTPNB IRET LGWE MBL MGDLE
+  MGDLS MGTPS ORET PRDT PWBT RDTN RET RREN STOV TERM_CRENA TERM_CRENB
+  TERM_GDLA TERM_GDLA_ TERM_GDLB TERM_GDLB_ TERM_WEIAJ TERM_WEIBJ TERM_YSNA
+  TERM_YSNB TIEHI TIELO WBT WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A
+  YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCTRLX_L: 442 flat devices **
XI0_0 AGTP AGTPN AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N CEI CLK EMA0 EMA1
+  EMA2 FIOBTPA FIOBTPB FIOGTPA FIOGTPA FIOGTPB GTP GTPDE GTPDS GWEI GWENA
+  GWENA GWENB IOBTPA IOBTPB IOGTPNA IOGTPNA IOGTPNB IRET LGWE MBL MBL MBLDLY1
+  MBLDLY2 MBLDLY3 MBLDLY4 MBLDLY5 MGDLE MGDLS MGTPS ORET PRDT PWBT RDTN RET
+  RREN STOV TERM_CRENA TERM_CRENB TERM_GDLA TERM_GDLA_ TERM_GDLB TERM_GDLB_
+  TERM_WEIAJ TERM_WEIBJ TERM_YSNA TERM_YSNB TIEHI TIELO WBT WEA WEB YP1_0_A
+  YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCTRL
.ENDS pe_spad_1024x16_dpCTRLX_L
****
.SUBCKT pe_spad_1024x16_dpGCTRL_L AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N
+  AI9N AI10N AI11N AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12 AX0N AX1N
+  AX2N AX3N AX4N AX5N AY0N AY1N AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N
+  CEI CLK EMA0 EMA1 EMA2 FIOBTPA FIOBTPB FIOGTPA FIOGTPB GTP GTPDE GTPDS GWEI
+  GWENA GWENB IOBTPA IOBTPB IOGTPNA IOGTPNB IRET LGWE MBL MGDLE MGDLS MGTPS
+  ORET PRDT PRRA0N PRRA1N PWBT RDTN RET RRA0 RRA0_ RRA1 RRA1_ RREN STOV
+  TERM_CRENA TERM_CRENB TERM_GDLA TERM_GDLA_ TERM_GDLB TERM_GDLB_ TERM_WEIAJ
+  TERM_WEIBJ TERM_YSNA TERM_YSNB TIEHI TIELO WBT WEA WEB YP1_0_A YP1_0_B
+  YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpGCTRL_L: 620 flat devices **
XI0_0 AGTP AGTPN AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N AI9N AI10N AI11N
+  AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12 AX0N AX1N AX2N AX3N AX4N AX5N
+  AY0N AY1N AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N FIOGTPA FIOGTPB GWENA
+  GWENB IOGTPNA IOGTPNB PRRA0N PRRA1N RET RRA0 RRA0_ RRA1 RRA1_ RREN TIELO
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpALX_L
XI1_0 AGTP AGTPN AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N CEI CLK EMA0 EMA1
+  EMA2 FIOBTPA FIOBTPB FIOGTPA FIOGTPB GTP GTPDE GTPDS GWEI GWENA GWENB
+  IOBTPA IOBTPB IOGTPNA IOGTPNB IRET LGWE MBL MGDLE MGDLS MGTPS ORET PRDT
+  PWBT RDTN RET RREN STOV TERM_CRENA TERM_CRENB TERM_GDLA TERM_GDLA_
+  TERM_GDLB TERM_GDLB_ TERM_WEIAJ TERM_WEIBJ TERM_YSNA TERM_YSNB TIEHI TIELO
+  WBT WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCTRLX_L
.ENDS pe_spad_1024x16_dpGCTRL_L
****
.SUBCKT pe_spad_1024x16_dpALX_R AGTP AGTPN AI0N AI1N AI2N AI3N AI4N AI5N AI6N
+  AI7N AI8N AI9N AI10N AI11N AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12
+  AX0N AX1N AX2N AX3N AX4N AX5N AY0N AY1N AY2N_A AY2N_B AY3N_A AY3N_B BS0N
+  BS1N BS2N FIOGTPA FIOGTPB GWENA GWENB IOGTPNA IOGTPNB PRRA0N PRRA1N RET
+  RRA0 RRA0_ RRA1 RRA1_ RREN TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpALX_R: 178 flat devices **
XI0_0 AGTP AGTPN AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N AI9N AI10N AI11N
+  AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12 AX0N AX1N AX2N AX3N AX4N AX5N
+  AY0N AY1N AY2N_B AY2N_A AY2N_B AY3N_B AY3N_A AY3N_B BS0N BS1N BS2N FIOGTPA
+  FIOGTPB GWENA GWENB IOGTPNA IOGTPNB PRRA0N PRRA1N RET RRA0 RRA0_ RRA1 RRA1_
+  RREN TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpAL
.ENDS pe_spad_1024x16_dpALX_R
****
.SUBCKT pe_spad_1024x16_dpCTRLX_R AGTP AGTPN AY2N_A AY2N_B AY3N_A AY3N_B BS0N
+  BS1N BS2N CEI CLK EMA0 EMA1 EMA2 FIOBTPA FIOBTPB FIOGTPA FIOGTPB GTP GTPDE
+  GTPDS GWEI GWENA GWENB IOBTPA IOBTPB IOGTPNA IOGTPNB IRET LGWE MBL MGDLE
+  MGDLS MGTPS ORET PRDT PWBT RDTN RET RREN STOV TERM_CRENA TERM_CRENB
+  TERM_GDLA TERM_GDLA_ TERM_GDLB TERM_GDLB_ TERM_WEIAJ TERM_WEIBJ TERM_YSNA
+  TERM_YSNB TIEHI TIELO WBT WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A
+  YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCTRLX_R: 442 flat devices **
XI0_0 AGTP AGTPN AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N CEI CLK EMA0 EMA1
+  EMA2 FIOBTPA FIOBTPB FIOGTPB FIOGTPA FIOGTPB GTP GTPDE GTPDS GWEI GWENB
+  GWENA GWENB IOBTPA IOBTPB IOGTPNB IOGTPNA IOGTPNB IRET LGWE MBL MBL MBLDLY1
+  MBLDLY2 MBLDLY3 MBLDLY4 MBLDLY5 MGDLE MGDLS MGTPS ORET PRDT PWBT RDTN RET
+  RREN STOV TERM_CRENA TERM_CRENB TERM_GDLA TERM_GDLA_ TERM_GDLB TERM_GDLB_
+  TERM_WEIAJ TERM_WEIBJ TERM_YSNA TERM_YSNB TIEHI TIELO WBT WEA WEB YP1_0_A
+  YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCTRL
.ENDS pe_spad_1024x16_dpCTRLX_R
****
.SUBCKT pe_spad_1024x16_dpGCTRL_R AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N
+  AI9N AI10N AI11N AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12 AX0N AX1N
+  AX2N AX3N AX4N AX5N AY0N AY1N AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N
+  CEI CLK EMA0 EMA1 EMA2 FIOBTPA FIOBTPB FIOGTPA FIOGTPB GTP GTPDE GTPDS GWEI
+  GWENA GWENB IOBTPA IOBTPB IOGTPNA IOGTPNB IRET LGWE MBL MGDLE MGDLS MGTPS
+  ORET PRDT PRRA0N PRRA1N PWBT RDTN RET RRA0 RRA0_ RRA1 RRA1_ RREN STOV
+  TERM_CRENA TERM_CRENB TERM_GDLA TERM_GDLA_ TERM_GDLB TERM_GDLB_ TERM_WEIAJ
+  TERM_WEIBJ TERM_YSNA TERM_YSNB TIEHI TIELO WBT WEA WEB YP1_0_A YP1_0_B
+  YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpGCTRL_R: 620 flat devices **
XI0_0 AGTP AGTPN AI0N AI1N AI2N AI3N AI4N AI5N AI6N AI7N AI8N AI9N AI10N AI11N
+  AI12N AO4 AO5 AO6 AO7 AO8 AO9 AO10 AO11 AO12 AX0N AX1N AX2N AX3N AX4N AX5N
+  AY0N AY1N AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N FIOGTPA FIOGTPB GWENA
+  GWENB IOGTPNA IOGTPNB PRRA0N PRRA1N RET RRA0 RRA0_ RRA1 RRA1_ RREN TIELO
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpALX_R
XI1_0 AGTP AGTPN AY2N_A AY2N_B AY3N_A AY3N_B BS0N BS1N BS2N CEI CLK EMA0 EMA1
+  EMA2 FIOBTPA FIOBTPB FIOGTPA FIOGTPB GTP GTPDE GTPDS GWEI GWENA GWENB
+  IOBTPA IOBTPB IOGTPNA IOGTPNB IRET LGWE MBL MGDLE MGDLS MGTPS ORET PRDT
+  PWBT RDTN RET RREN STOV TERM_CRENA TERM_CRENB TERM_GDLA TERM_GDLA_
+  TERM_GDLB TERM_GDLB_ TERM_WEIAJ TERM_WEIBJ TERM_YSNA TERM_YSNB TIEHI TIELO
+  WBT WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCTRLX_R
.ENDS pe_spad_1024x16_dpGCTRL_R
****
.SUBCKT pe_spad_1024x16_dpIO_ROW_R BWEIA_0 BWEIA_1 BWEIA_2 BWEIA_3 BWEIA_4
+  BWEIA_5 BWEIA_6 BWEIA_7 BWEIB_0 BWEIB_1 BWEIB_2 BWEIB_3 BWEIB_4 BWEIB_5
+  BWEIB_6 BWEIB_7 CRENA DNA_0 DNA_1 DNA_2 DNA_3 DNA_4 DNA_5 DNA_6 DNA_7 DNB_0
+  DNB_1 DNB_2 DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 FIOBTPA FIOBTPB GDLA_0 GDLA_1
+  GDLA_2 GDLA_3 GDLA_4 GDLA_5 GDLA_6 GDLA_7 GDLA_8 GDLA_9 GDLA_10 GDLA_11
+  GDLA_12 GDLA_13 GDLA_14 GDLA_15 GDLA_16 GDLA_17 GDLA_18 GDLA_19 GDLA_20
+  GDLA_21 GDLA_22 GDLA_23 GDLA_24 GDLA_25 GDLA_26 GDLA_27 GDLA_28 GDLA_29
+  GDLA_30 GDLA_31 GDLA__0 GDLA__1 GDLA__2 GDLA__3 GDLA__4 GDLA__5 GDLA__6
+  GDLA__7 GDLA__8 GDLA__9 GDLA__10 GDLA__11 GDLA__12 GDLA__13 GDLA__14
+  GDLA__15 GDLA__16 GDLA__17 GDLA__18 GDLA__19 GDLA__20 GDLA__21 GDLA__22
+  GDLA__23 GDLA__24 GDLA__25 GDLA__26 GDLA__27 GDLA__28 GDLA__29 GDLA__30
+  GDLA__31 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6 GDLB_7 GDLB_8
+  GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15 GDLB_16 GDLB_17
+  GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23 GDLB_24 GDLB_25 GDLB_26
+  GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB__0 GDLB__1 GDLB__2 GDLB__3
+  GDLB__4 GDLB__5 GDLB__6 GDLB__7 GDLB__8 GDLB__9 GDLB__10 GDLB__11 GDLB__12
+  GDLB__13 GDLB__14 GDLB__15 GDLB__16 GDLB__17 GDLB__18 GDLB__19 GDLB__20
+  GDLB__21 GDLB__22 GDLB__23 GDLB__24 GDLB__25 GDLB__26 GDLB__27 GDLB__28
+  GDLB__29 GDLB__30 GDLB__31 IOBTPA IOBTPB IRET ORET QA__0 QA__1 QA__2 QA__3
+  QA__4 QA__5 QA__6 QA__7 QB__0 QB__1 QB__2 QB__3 QB__4 QB__5 QB__6 QB__7
+  STUB_BLA0_0 STUB_BLA0_1 STUB_BLA0_2 STUB_BLA0_3 STUB_BLA0_4 STUB_BLA0_5
+  STUB_BLA0_6 STUB_BLA0_7 STUB_BLA0_8 STUB_BLA0_9 STUB_BLA0_10 STUB_BLA0_11
+  STUB_BLA0_12 STUB_BLA0_13 STUB_BLA0_14 STUB_BLA0_15 STUB_BLA0_16
+  STUB_BLA0_17 STUB_BLA0_18 STUB_BLA0_19 STUB_BLA0_20 STUB_BLA0_21
+  STUB_BLA0_22 STUB_BLA0_23 STUB_BLA0_24 STUB_BLA0_25 STUB_BLA0_26
+  STUB_BLA0_27 STUB_BLA0_28 STUB_BLA0_29 STUB_BLA0_30 STUB_BLA0_31
+  STUB_BLA0__0 STUB_BLA0__1 STUB_BLA0__2 STUB_BLA0__3 STUB_BLA0__4
+  STUB_BLA0__5 STUB_BLA0__6 STUB_BLA0__7 STUB_BLA0__8 STUB_BLA0__9
+  STUB_BLA0__10 STUB_BLA0__11 STUB_BLA0__12 STUB_BLA0__13 STUB_BLA0__14
+  STUB_BLA0__15 STUB_BLA0__16 STUB_BLA0__17 STUB_BLA0__18 STUB_BLA0__19
+  STUB_BLA0__20 STUB_BLA0__21 STUB_BLA0__22 STUB_BLA0__23 STUB_BLA0__24
+  STUB_BLA0__25 STUB_BLA0__26 STUB_BLA0__27 STUB_BLA0__28 STUB_BLA0__29
+  STUB_BLA0__30 STUB_BLA0__31 STUB_BLA1_0 STUB_BLA1_1 STUB_BLA1_2 STUB_BLA1_3
+  STUB_BLA1_4 STUB_BLA1_5 STUB_BLA1_6 STUB_BLA1_7 STUB_BLA1_8 STUB_BLA1_9
+  STUB_BLA1_10 STUB_BLA1_11 STUB_BLA1_12 STUB_BLA1_13 STUB_BLA1_14
+  STUB_BLA1_15 STUB_BLA1_16 STUB_BLA1_17 STUB_BLA1_18 STUB_BLA1_19
+  STUB_BLA1_20 STUB_BLA1_21 STUB_BLA1_22 STUB_BLA1_23 STUB_BLA1_24
+  STUB_BLA1_25 STUB_BLA1_26 STUB_BLA1_27 STUB_BLA1_28 STUB_BLA1_29
+  STUB_BLA1_30 STUB_BLA1_31 STUB_BLA1__0 STUB_BLA1__1 STUB_BLA1__2
+  STUB_BLA1__3 STUB_BLA1__4 STUB_BLA1__5 STUB_BLA1__6 STUB_BLA1__7
+  STUB_BLA1__8 STUB_BLA1__9 STUB_BLA1__10 STUB_BLA1__11 STUB_BLA1__12
+  STUB_BLA1__13 STUB_BLA1__14 STUB_BLA1__15 STUB_BLA1__16 STUB_BLA1__17
+  STUB_BLA1__18 STUB_BLA1__19 STUB_BLA1__20 STUB_BLA1__21 STUB_BLA1__22
+  STUB_BLA1__23 STUB_BLA1__24 STUB_BLA1__25 STUB_BLA1__26 STUB_BLA1__27
+  STUB_BLA1__28 STUB_BLA1__29 STUB_BLA1__30 STUB_BLA1__31 STUB_BLA2_0
+  STUB_BLA2_1 STUB_BLA2_2 STUB_BLA2_3 STUB_BLA2_4 STUB_BLA2_5 STUB_BLA2_6
+  STUB_BLA2_7 STUB_BLA2_8 STUB_BLA2_9 STUB_BLA2_10 STUB_BLA2_11 STUB_BLA2_12
+  STUB_BLA2_13 STUB_BLA2_14 STUB_BLA2_15 STUB_BLA2_16 STUB_BLA2_17
+  STUB_BLA2_18 STUB_BLA2_19 STUB_BLA2_20 STUB_BLA2_21 STUB_BLA2_22
+  STUB_BLA2_23 STUB_BLA2_24 STUB_BLA2_25 STUB_BLA2_26 STUB_BLA2_27
+  STUB_BLA2_28 STUB_BLA2_29 STUB_BLA2_30 STUB_BLA2_31 STUB_BLA2__0
+  STUB_BLA2__1 STUB_BLA2__2 STUB_BLA2__3 STUB_BLA2__4 STUB_BLA2__5
+  STUB_BLA2__6 STUB_BLA2__7 STUB_BLA2__8 STUB_BLA2__9 STUB_BLA2__10
+  STUB_BLA2__11 STUB_BLA2__12 STUB_BLA2__13 STUB_BLA2__14 STUB_BLA2__15
+  STUB_BLA2__16 STUB_BLA2__17 STUB_BLA2__18 STUB_BLA2__19 STUB_BLA2__20
+  STUB_BLA2__21 STUB_BLA2__22 STUB_BLA2__23 STUB_BLA2__24 STUB_BLA2__25
+  STUB_BLA2__26 STUB_BLA2__27 STUB_BLA2__28 STUB_BLA2__29 STUB_BLA2__30
+  STUB_BLA2__31 STUB_BLA3_0 STUB_BLA3_1 STUB_BLA3_2 STUB_BLA3_3 STUB_BLA3_4
+  STUB_BLA3_5 STUB_BLA3_6 STUB_BLA3_7 STUB_BLA3_8 STUB_BLA3_9 STUB_BLA3_10
+  STUB_BLA3_11 STUB_BLA3_12 STUB_BLA3_13 STUB_BLA3_14 STUB_BLA3_15
+  STUB_BLA3_16 STUB_BLA3_17 STUB_BLA3_18 STUB_BLA3_19 STUB_BLA3_20
+  STUB_BLA3_21 STUB_BLA3_22 STUB_BLA3_23 STUB_BLA3_24 STUB_BLA3_25
+  STUB_BLA3_26 STUB_BLA3_27 STUB_BLA3_28 STUB_BLA3_29 STUB_BLA3_30
+  STUB_BLA3_31 STUB_BLA3__0 STUB_BLA3__1 STUB_BLA3__2 STUB_BLA3__3
+  STUB_BLA3__4 STUB_BLA3__5 STUB_BLA3__6 STUB_BLA3__7 STUB_BLA3__8
+  STUB_BLA3__9 STUB_BLA3__10 STUB_BLA3__11 STUB_BLA3__12 STUB_BLA3__13
+  STUB_BLA3__14 STUB_BLA3__15 STUB_BLA3__16 STUB_BLA3__17 STUB_BLA3__18
+  STUB_BLA3__19 STUB_BLA3__20 STUB_BLA3__21 STUB_BLA3__22 STUB_BLA3__23
+  STUB_BLA3__24 STUB_BLA3__25 STUB_BLA3__26 STUB_BLA3__27 STUB_BLA3__28
+  STUB_BLA3__29 STUB_BLA3__30 STUB_BLA3__31 STUB_BLB0_0 STUB_BLB0_1
+  STUB_BLB0_2 STUB_BLB0_3 STUB_BLB0_4 STUB_BLB0_5 STUB_BLB0_6 STUB_BLB0_7
+  STUB_BLB0_8 STUB_BLB0_9 STUB_BLB0_10 STUB_BLB0_11 STUB_BLB0_12 STUB_BLB0_13
+  STUB_BLB0_14 STUB_BLB0_15 STUB_BLB0_16 STUB_BLB0_17 STUB_BLB0_18
+  STUB_BLB0_19 STUB_BLB0_20 STUB_BLB0_21 STUB_BLB0_22 STUB_BLB0_23
+  STUB_BLB0_24 STUB_BLB0_25 STUB_BLB0_26 STUB_BLB0_27 STUB_BLB0_28
+  STUB_BLB0_29 STUB_BLB0_30 STUB_BLB0_31 STUB_BLB0__0 STUB_BLB0__1
+  STUB_BLB0__2 STUB_BLB0__3 STUB_BLB0__4 STUB_BLB0__5 STUB_BLB0__6
+  STUB_BLB0__7 STUB_BLB0__8 STUB_BLB0__9 STUB_BLB0__10 STUB_BLB0__11
+  STUB_BLB0__12 STUB_BLB0__13 STUB_BLB0__14 STUB_BLB0__15 STUB_BLB0__16
+  STUB_BLB0__17 STUB_BLB0__18 STUB_BLB0__19 STUB_BLB0__20 STUB_BLB0__21
+  STUB_BLB0__22 STUB_BLB0__23 STUB_BLB0__24 STUB_BLB0__25 STUB_BLB0__26
+  STUB_BLB0__27 STUB_BLB0__28 STUB_BLB0__29 STUB_BLB0__30 STUB_BLB0__31
+  STUB_BLB1_0 STUB_BLB1_1 STUB_BLB1_2 STUB_BLB1_3 STUB_BLB1_4 STUB_BLB1_5
+  STUB_BLB1_6 STUB_BLB1_7 STUB_BLB1_8 STUB_BLB1_9 STUB_BLB1_10 STUB_BLB1_11
+  STUB_BLB1_12 STUB_BLB1_13 STUB_BLB1_14 STUB_BLB1_15 STUB_BLB1_16
+  STUB_BLB1_17 STUB_BLB1_18 STUB_BLB1_19 STUB_BLB1_20 STUB_BLB1_21
+  STUB_BLB1_22 STUB_BLB1_23 STUB_BLB1_24 STUB_BLB1_25 STUB_BLB1_26
+  STUB_BLB1_27 STUB_BLB1_28 STUB_BLB1_29 STUB_BLB1_30 STUB_BLB1_31
+  STUB_BLB1__0 STUB_BLB1__1 STUB_BLB1__2 STUB_BLB1__3 STUB_BLB1__4
+  STUB_BLB1__5 STUB_BLB1__6 STUB_BLB1__7 STUB_BLB1__8 STUB_BLB1__9
+  STUB_BLB1__10 STUB_BLB1__11 STUB_BLB1__12 STUB_BLB1__13 STUB_BLB1__14
+  STUB_BLB1__15 STUB_BLB1__16 STUB_BLB1__17 STUB_BLB1__18 STUB_BLB1__19
+  STUB_BLB1__20 STUB_BLB1__21 STUB_BLB1__22 STUB_BLB1__23 STUB_BLB1__24
+  STUB_BLB1__25 STUB_BLB1__26 STUB_BLB1__27 STUB_BLB1__28 STUB_BLB1__29
+  STUB_BLB1__30 STUB_BLB1__31 STUB_BLB2_0 STUB_BLB2_1 STUB_BLB2_2 STUB_BLB2_3
+  STUB_BLB2_4 STUB_BLB2_5 STUB_BLB2_6 STUB_BLB2_7 STUB_BLB2_8 STUB_BLB2_9
+  STUB_BLB2_10 STUB_BLB2_11 STUB_BLB2_12 STUB_BLB2_13 STUB_BLB2_14
+  STUB_BLB2_15 STUB_BLB2_16 STUB_BLB2_17 STUB_BLB2_18 STUB_BLB2_19
+  STUB_BLB2_20 STUB_BLB2_21 STUB_BLB2_22 STUB_BLB2_23 STUB_BLB2_24
+  STUB_BLB2_25 STUB_BLB2_26 STUB_BLB2_27 STUB_BLB2_28 STUB_BLB2_29
+  STUB_BLB2_30 STUB_BLB2_31 STUB_BLB2__0 STUB_BLB2__1 STUB_BLB2__2
+  STUB_BLB2__3 STUB_BLB2__4 STUB_BLB2__5 STUB_BLB2__6 STUB_BLB2__7
+  STUB_BLB2__8 STUB_BLB2__9 STUB_BLB2__10 STUB_BLB2__11 STUB_BLB2__12
+  STUB_BLB2__13 STUB_BLB2__14 STUB_BLB2__15 STUB_BLB2__16 STUB_BLB2__17
+  STUB_BLB2__18 STUB_BLB2__19 STUB_BLB2__20 STUB_BLB2__21 STUB_BLB2__22
+  STUB_BLB2__23 STUB_BLB2__24 STUB_BLB2__25 STUB_BLB2__26 STUB_BLB2__27
+  STUB_BLB2__28 STUB_BLB2__29 STUB_BLB2__30 STUB_BLB2__31 STUB_BLB3_0
+  STUB_BLB3_1 STUB_BLB3_2 STUB_BLB3_3 STUB_BLB3_4 STUB_BLB3_5 STUB_BLB3_6
+  STUB_BLB3_7 STUB_BLB3_8 STUB_BLB3_9 STUB_BLB3_10 STUB_BLB3_11 STUB_BLB3_12
+  STUB_BLB3_13 STUB_BLB3_14 STUB_BLB3_15 STUB_BLB3_16 STUB_BLB3_17
+  STUB_BLB3_18 STUB_BLB3_19 STUB_BLB3_20 STUB_BLB3_21 STUB_BLB3_22
+  STUB_BLB3_23 STUB_BLB3_24 STUB_BLB3_25 STUB_BLB3_26 STUB_BLB3_27
+  STUB_BLB3_28 STUB_BLB3_29 STUB_BLB3_30 STUB_BLB3_31 STUB_BLB3__0
+  STUB_BLB3__1 STUB_BLB3__2 STUB_BLB3__3 STUB_BLB3__4 STUB_BLB3__5
+  STUB_BLB3__6 STUB_BLB3__7 STUB_BLB3__8 STUB_BLB3__9 STUB_BLB3__10
+  STUB_BLB3__11 STUB_BLB3__12 STUB_BLB3__13 STUB_BLB3__14 STUB_BLB3__15
+  STUB_BLB3__16 STUB_BLB3__17 STUB_BLB3__18 STUB_BLB3__19 STUB_BLB3__20
+  STUB_BLB3__21 STUB_BLB3__22 STUB_BLB3__23 STUB_BLB3__24 STUB_BLB3__25
+  STUB_BLB3__26 STUB_BLB3__27 STUB_BLB3__28 STUB_BLB3__29 STUB_BLB3__30
+  STUB_BLB3__31 TIELO WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B
+  YP1_3_A YP1_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpIO_ROW_R: 6832 flat devices **
XI0_0 BWEIA_0 BWEIB_0 CRENA CRENA DNA_0 DNB_0 FIOBTPA FIOBTPB GDLA_0 GDLA_1
+  GDLA_2 GDLA_3 GDLA__0 GDLA__1 GDLA__2 GDLA__3 GDLB_0 GDLB_1 GDLB_2 GDLB_3
+  GDLB__0 GDLB__1 GDLB__2 GDLB__3 IOBTPA IOBTPB IRET ORET QA__0 QB__0
+  STUB_BLA0_0 STUB_BLA0_1 STUB_BLA0_2 STUB_BLA0_3 STUB_BLA0__0 STUB_BLA0__1
+  STUB_BLA0__2 STUB_BLA0__3 STUB_BLA1_0 STUB_BLA1_1 STUB_BLA1_2 STUB_BLA1_3
+  STUB_BLA1__0 STUB_BLA1__1 STUB_BLA1__2 STUB_BLA1__3 STUB_BLA2_0 STUB_BLA2_1
+  STUB_BLA2_2 STUB_BLA2_3 STUB_BLA2__0 STUB_BLA2__1 STUB_BLA2__2 STUB_BLA2__3
+  STUB_BLA3_0 STUB_BLA3_1 STUB_BLA3_2 STUB_BLA3_3 STUB_BLA3__0 STUB_BLA3__1
+  STUB_BLA3__2 STUB_BLA3__3 STUB_BLB0_0 STUB_BLB0_1 STUB_BLB0_2 STUB_BLB0_3
+  STUB_BLB0__0 STUB_BLB0__1 STUB_BLB0__2 STUB_BLB0__3 STUB_BLB1_0 STUB_BLB1_1
+  STUB_BLB1_2 STUB_BLB1_3 STUB_BLB1__0 STUB_BLB1__1 STUB_BLB1__2 STUB_BLB1__3
+  STUB_BLB2_0 STUB_BLB2_1 STUB_BLB2_2 STUB_BLB2_3 STUB_BLB2__0 STUB_BLB2__1
+  STUB_BLB2__2 STUB_BLB2__3 STUB_BLB3_0 STUB_BLB3_1 STUB_BLB3_2 STUB_BLB3_3
+  STUB_BLB3__0 STUB_BLB3__1 STUB_BLB3__2 STUB_BLB3__3 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI1_0 BWEIA_1 BWEIB_1 CRENA CRENA DNA_1 DNB_1 FIOBTPA FIOBTPB GDLA_4 GDLA_5
+  GDLA_6 GDLA_7 GDLA__4 GDLA__5 GDLA__6 GDLA__7 GDLB_4 GDLB_5 GDLB_6 GDLB_7
+  GDLB__4 GDLB__5 GDLB__6 GDLB__7 IOBTPA IOBTPB IRET ORET QA__1 QB__1
+  STUB_BLA0_4 STUB_BLA0_5 STUB_BLA0_6 STUB_BLA0_7 STUB_BLA0__4 STUB_BLA0__5
+  STUB_BLA0__6 STUB_BLA0__7 STUB_BLA1_4 STUB_BLA1_5 STUB_BLA1_6 STUB_BLA1_7
+  STUB_BLA1__4 STUB_BLA1__5 STUB_BLA1__6 STUB_BLA1__7 STUB_BLA2_4 STUB_BLA2_5
+  STUB_BLA2_6 STUB_BLA2_7 STUB_BLA2__4 STUB_BLA2__5 STUB_BLA2__6 STUB_BLA2__7
+  STUB_BLA3_4 STUB_BLA3_5 STUB_BLA3_6 STUB_BLA3_7 STUB_BLA3__4 STUB_BLA3__5
+  STUB_BLA3__6 STUB_BLA3__7 STUB_BLB0_4 STUB_BLB0_5 STUB_BLB0_6 STUB_BLB0_7
+  STUB_BLB0__4 STUB_BLB0__5 STUB_BLB0__6 STUB_BLB0__7 STUB_BLB1_4 STUB_BLB1_5
+  STUB_BLB1_6 STUB_BLB1_7 STUB_BLB1__4 STUB_BLB1__5 STUB_BLB1__6 STUB_BLB1__7
+  STUB_BLB2_4 STUB_BLB2_5 STUB_BLB2_6 STUB_BLB2_7 STUB_BLB2__4 STUB_BLB2__5
+  STUB_BLB2__6 STUB_BLB2__7 STUB_BLB3_4 STUB_BLB3_5 STUB_BLB3_6 STUB_BLB3_7
+  STUB_BLB3__4 STUB_BLB3__5 STUB_BLB3__6 STUB_BLB3__7 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI2_0 BWEIA_2 BWEIB_2 CRENA CRENA DNA_2 DNB_2 FIOBTPA FIOBTPB GDLA_8 GDLA_9
+  GDLA_10 GDLA_11 GDLA__8 GDLA__9 GDLA__10 GDLA__11 GDLB_8 GDLB_9 GDLB_10
+  GDLB_11 GDLB__8 GDLB__9 GDLB__10 GDLB__11 IOBTPA IOBTPB IRET ORET QA__2
+  QB__2 STUB_BLA0_8 STUB_BLA0_9 STUB_BLA0_10 STUB_BLA0_11 STUB_BLA0__8
+  STUB_BLA0__9 STUB_BLA0__10 STUB_BLA0__11 STUB_BLA1_8 STUB_BLA1_9
+  STUB_BLA1_10 STUB_BLA1_11 STUB_BLA1__8 STUB_BLA1__9 STUB_BLA1__10
+  STUB_BLA1__11 STUB_BLA2_8 STUB_BLA2_9 STUB_BLA2_10 STUB_BLA2_11
+  STUB_BLA2__8 STUB_BLA2__9 STUB_BLA2__10 STUB_BLA2__11 STUB_BLA3_8
+  STUB_BLA3_9 STUB_BLA3_10 STUB_BLA3_11 STUB_BLA3__8 STUB_BLA3__9
+  STUB_BLA3__10 STUB_BLA3__11 STUB_BLB0_8 STUB_BLB0_9 STUB_BLB0_10
+  STUB_BLB0_11 STUB_BLB0__8 STUB_BLB0__9 STUB_BLB0__10 STUB_BLB0__11
+  STUB_BLB1_8 STUB_BLB1_9 STUB_BLB1_10 STUB_BLB1_11 STUB_BLB1__8 STUB_BLB1__9
+  STUB_BLB1__10 STUB_BLB1__11 STUB_BLB2_8 STUB_BLB2_9 STUB_BLB2_10
+  STUB_BLB2_11 STUB_BLB2__8 STUB_BLB2__9 STUB_BLB2__10 STUB_BLB2__11
+  STUB_BLB3_8 STUB_BLB3_9 STUB_BLB3_10 STUB_BLB3_11 STUB_BLB3__8 STUB_BLB3__9
+  STUB_BLB3__10 STUB_BLB3__11 CRENA TIELO WEA WEB YP1_0_A YP1_0_B YP1_1_A
+  YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpIOX
XI3_0 BWEIA_3 BWEIB_3 CRENA CRENA DNA_3 DNB_3 FIOBTPA FIOBTPB GDLA_12 GDLA_13
+  GDLA_14 GDLA_15 GDLA__12 GDLA__13 GDLA__14 GDLA__15 GDLB_12 GDLB_13 GDLB_14
+  GDLB_15 GDLB__12 GDLB__13 GDLB__14 GDLB__15 IOBTPA IOBTPB IRET ORET QA__3
+  QB__3 STUB_BLA0_12 STUB_BLA0_13 STUB_BLA0_14 STUB_BLA0_15 STUB_BLA0__12
+  STUB_BLA0__13 STUB_BLA0__14 STUB_BLA0__15 STUB_BLA1_12 STUB_BLA1_13
+  STUB_BLA1_14 STUB_BLA1_15 STUB_BLA1__12 STUB_BLA1__13 STUB_BLA1__14
+  STUB_BLA1__15 STUB_BLA2_12 STUB_BLA2_13 STUB_BLA2_14 STUB_BLA2_15
+  STUB_BLA2__12 STUB_BLA2__13 STUB_BLA2__14 STUB_BLA2__15 STUB_BLA3_12
+  STUB_BLA3_13 STUB_BLA3_14 STUB_BLA3_15 STUB_BLA3__12 STUB_BLA3__13
+  STUB_BLA3__14 STUB_BLA3__15 STUB_BLB0_12 STUB_BLB0_13 STUB_BLB0_14
+  STUB_BLB0_15 STUB_BLB0__12 STUB_BLB0__13 STUB_BLB0__14 STUB_BLB0__15
+  STUB_BLB1_12 STUB_BLB1_13 STUB_BLB1_14 STUB_BLB1_15 STUB_BLB1__12
+  STUB_BLB1__13 STUB_BLB1__14 STUB_BLB1__15 STUB_BLB2_12 STUB_BLB2_13
+  STUB_BLB2_14 STUB_BLB2_15 STUB_BLB2__12 STUB_BLB2__13 STUB_BLB2__14
+  STUB_BLB2__15 STUB_BLB3_12 STUB_BLB3_13 STUB_BLB3_14 STUB_BLB3_15
+  STUB_BLB3__12 STUB_BLB3__13 STUB_BLB3__14 STUB_BLB3__15 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI4_0 BWEIA_4 BWEIB_4 CRENA CRENA DNA_4 DNB_4 FIOBTPA FIOBTPB GDLA_16 GDLA_17
+  GDLA_18 GDLA_19 GDLA__16 GDLA__17 GDLA__18 GDLA__19 GDLB_16 GDLB_17 GDLB_18
+  GDLB_19 GDLB__16 GDLB__17 GDLB__18 GDLB__19 IOBTPA IOBTPB IRET ORET QA__4
+  QB__4 STUB_BLA0_16 STUB_BLA0_17 STUB_BLA0_18 STUB_BLA0_19 STUB_BLA0__16
+  STUB_BLA0__17 STUB_BLA0__18 STUB_BLA0__19 STUB_BLA1_16 STUB_BLA1_17
+  STUB_BLA1_18 STUB_BLA1_19 STUB_BLA1__16 STUB_BLA1__17 STUB_BLA1__18
+  STUB_BLA1__19 STUB_BLA2_16 STUB_BLA2_17 STUB_BLA2_18 STUB_BLA2_19
+  STUB_BLA2__16 STUB_BLA2__17 STUB_BLA2__18 STUB_BLA2__19 STUB_BLA3_16
+  STUB_BLA3_17 STUB_BLA3_18 STUB_BLA3_19 STUB_BLA3__16 STUB_BLA3__17
+  STUB_BLA3__18 STUB_BLA3__19 STUB_BLB0_16 STUB_BLB0_17 STUB_BLB0_18
+  STUB_BLB0_19 STUB_BLB0__16 STUB_BLB0__17 STUB_BLB0__18 STUB_BLB0__19
+  STUB_BLB1_16 STUB_BLB1_17 STUB_BLB1_18 STUB_BLB1_19 STUB_BLB1__16
+  STUB_BLB1__17 STUB_BLB1__18 STUB_BLB1__19 STUB_BLB2_16 STUB_BLB2_17
+  STUB_BLB2_18 STUB_BLB2_19 STUB_BLB2__16 STUB_BLB2__17 STUB_BLB2__18
+  STUB_BLB2__19 STUB_BLB3_16 STUB_BLB3_17 STUB_BLB3_18 STUB_BLB3_19
+  STUB_BLB3__16 STUB_BLB3__17 STUB_BLB3__18 STUB_BLB3__19 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI5_0 BWEIA_5 BWEIB_5 CRENA CRENA DNA_5 DNB_5 FIOBTPA FIOBTPB GDLA_20 GDLA_21
+  GDLA_22 GDLA_23 GDLA__20 GDLA__21 GDLA__22 GDLA__23 GDLB_20 GDLB_21 GDLB_22
+  GDLB_23 GDLB__20 GDLB__21 GDLB__22 GDLB__23 IOBTPA IOBTPB IRET ORET QA__5
+  QB__5 STUB_BLA0_20 STUB_BLA0_21 STUB_BLA0_22 STUB_BLA0_23 STUB_BLA0__20
+  STUB_BLA0__21 STUB_BLA0__22 STUB_BLA0__23 STUB_BLA1_20 STUB_BLA1_21
+  STUB_BLA1_22 STUB_BLA1_23 STUB_BLA1__20 STUB_BLA1__21 STUB_BLA1__22
+  STUB_BLA1__23 STUB_BLA2_20 STUB_BLA2_21 STUB_BLA2_22 STUB_BLA2_23
+  STUB_BLA2__20 STUB_BLA2__21 STUB_BLA2__22 STUB_BLA2__23 STUB_BLA3_20
+  STUB_BLA3_21 STUB_BLA3_22 STUB_BLA3_23 STUB_BLA3__20 STUB_BLA3__21
+  STUB_BLA3__22 STUB_BLA3__23 STUB_BLB0_20 STUB_BLB0_21 STUB_BLB0_22
+  STUB_BLB0_23 STUB_BLB0__20 STUB_BLB0__21 STUB_BLB0__22 STUB_BLB0__23
+  STUB_BLB1_20 STUB_BLB1_21 STUB_BLB1_22 STUB_BLB1_23 STUB_BLB1__20
+  STUB_BLB1__21 STUB_BLB1__22 STUB_BLB1__23 STUB_BLB2_20 STUB_BLB2_21
+  STUB_BLB2_22 STUB_BLB2_23 STUB_BLB2__20 STUB_BLB2__21 STUB_BLB2__22
+  STUB_BLB2__23 STUB_BLB3_20 STUB_BLB3_21 STUB_BLB3_22 STUB_BLB3_23
+  STUB_BLB3__20 STUB_BLB3__21 STUB_BLB3__22 STUB_BLB3__23 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI6_0 BWEIA_6 BWEIB_6 CRENA CRENA DNA_6 DNB_6 FIOBTPA FIOBTPB GDLA_24 GDLA_25
+  GDLA_26 GDLA_27 GDLA__24 GDLA__25 GDLA__26 GDLA__27 GDLB_24 GDLB_25 GDLB_26
+  GDLB_27 GDLB__24 GDLB__25 GDLB__26 GDLB__27 IOBTPA IOBTPB IRET ORET QA__6
+  QB__6 STUB_BLA0_24 STUB_BLA0_25 STUB_BLA0_26 STUB_BLA0_27 STUB_BLA0__24
+  STUB_BLA0__25 STUB_BLA0__26 STUB_BLA0__27 STUB_BLA1_24 STUB_BLA1_25
+  STUB_BLA1_26 STUB_BLA1_27 STUB_BLA1__24 STUB_BLA1__25 STUB_BLA1__26
+  STUB_BLA1__27 STUB_BLA2_24 STUB_BLA2_25 STUB_BLA2_26 STUB_BLA2_27
+  STUB_BLA2__24 STUB_BLA2__25 STUB_BLA2__26 STUB_BLA2__27 STUB_BLA3_24
+  STUB_BLA3_25 STUB_BLA3_26 STUB_BLA3_27 STUB_BLA3__24 STUB_BLA3__25
+  STUB_BLA3__26 STUB_BLA3__27 STUB_BLB0_24 STUB_BLB0_25 STUB_BLB0_26
+  STUB_BLB0_27 STUB_BLB0__24 STUB_BLB0__25 STUB_BLB0__26 STUB_BLB0__27
+  STUB_BLB1_24 STUB_BLB1_25 STUB_BLB1_26 STUB_BLB1_27 STUB_BLB1__24
+  STUB_BLB1__25 STUB_BLB1__26 STUB_BLB1__27 STUB_BLB2_24 STUB_BLB2_25
+  STUB_BLB2_26 STUB_BLB2_27 STUB_BLB2__24 STUB_BLB2__25 STUB_BLB2__26
+  STUB_BLB2__27 STUB_BLB3_24 STUB_BLB3_25 STUB_BLB3_26 STUB_BLB3_27
+  STUB_BLB3__24 STUB_BLB3__25 STUB_BLB3__26 STUB_BLB3__27 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
XI7_0 BWEIA_7 BWEIB_7 CRENA CRENA DNA_7 DNB_7 FIOBTPA FIOBTPB GDLA_28 GDLA_29
+  GDLA_30 GDLA_31 GDLA__28 GDLA__29 GDLA__30 GDLA__31 GDLB_28 GDLB_29 GDLB_30
+  GDLB_31 GDLB__28 GDLB__29 GDLB__30 GDLB__31 IOBTPA IOBTPB IRET ORET QA__7
+  QB__7 STUB_BLA0_28 STUB_BLA0_29 STUB_BLA0_30 STUB_BLA0_31 STUB_BLA0__28
+  STUB_BLA0__29 STUB_BLA0__30 STUB_BLA0__31 STUB_BLA1_28 STUB_BLA1_29
+  STUB_BLA1_30 STUB_BLA1_31 STUB_BLA1__28 STUB_BLA1__29 STUB_BLA1__30
+  STUB_BLA1__31 STUB_BLA2_28 STUB_BLA2_29 STUB_BLA2_30 STUB_BLA2_31
+  STUB_BLA2__28 STUB_BLA2__29 STUB_BLA2__30 STUB_BLA2__31 STUB_BLA3_28
+  STUB_BLA3_29 STUB_BLA3_30 STUB_BLA3_31 STUB_BLA3__28 STUB_BLA3__29
+  STUB_BLA3__30 STUB_BLA3__31 STUB_BLB0_28 STUB_BLB0_29 STUB_BLB0_30
+  STUB_BLB0_31 STUB_BLB0__28 STUB_BLB0__29 STUB_BLB0__30 STUB_BLB0__31
+  STUB_BLB1_28 STUB_BLB1_29 STUB_BLB1_30 STUB_BLB1_31 STUB_BLB1__28
+  STUB_BLB1__29 STUB_BLB1__30 STUB_BLB1__31 STUB_BLB2_28 STUB_BLB2_29
+  STUB_BLB2_30 STUB_BLB2_31 STUB_BLB2__28 STUB_BLB2__29 STUB_BLB2__30
+  STUB_BLB2__31 STUB_BLB3_28 STUB_BLB3_29 STUB_BLB3_30 STUB_BLB3_31
+  STUB_BLB3__28 STUB_BLB3__29 STUB_BLB3__30 STUB_BLB3__31 CRENA TIELO WEA WEB
+  YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpIOX
.ENDS pe_spad_1024x16_dpIO_ROW_R
****
.SUBCKT pe_spad_1024x16_dpGCTRL_ROW AI0N_0 AI0N_1 AI1N_0 AI1N_1 AI2N_0 AI2N_1
+  AI3N_0 AI3N_1 AI4N_0 AI4N_1 AI5N_0 AI5N_1 AI6N_0 AI6N_1 AI7N_0 AI7N_1
+  AI8N_0 AI8N_1 AI9N_0 AI9N_1 AI10N_0 AI10N_1 AI11N_0 AI11N_1 AI12N_0 AI12N_1
+  AO4_0 AO4_1 AO5_0 AO5_1 AO6_0 AO6_1 AO7_0 AO7_1 AO8_0 AO8_1 AO9_0 AO9_1
+  AO10_0 AO10_1 AO11_0 AO11_1 AO12_0 AO12_1 AX0N_0 AX0N_1 AX1N_0 AX1N_1
+  AX2N_0 AX2N_1 AX3N_0 AX3N_1 AX4N_0 AX4N_1 AX5N_0 AX5N_1 AY0N_0 AY0N_1
+  AY1N_0 AY1N_1 BS0N_0 BS0N_1 BS1N_0 BS1N_1 BS2N_0 BS2N_1 BWEIA_0 BWEIA_1
+  BWEIA_2 BWEIA_3 BWEIA_4 BWEIA_5 BWEIA_6 BWEIA_7 BWEIA_8 BWEIA_9 BWEIA_10
+  BWEIA_11 BWEIA_12 BWEIA_13 BWEIA_14 BWEIA_15 BWEIB_0 BWEIB_1 BWEIB_2
+  BWEIB_3 BWEIB_4 BWEIB_5 BWEIB_6 BWEIB_7 BWEIB_8 BWEIB_9 BWEIB_10 BWEIB_11
+  BWEIB_12 BWEIB_13 BWEIB_14 BWEIB_15 CEI_0 CEI_1 CLK_0 CLK_1 DNA_0 DNA_1
+  DNA_2 DNA_3 DNA_4 DNA_5 DNA_6 DNA_7 DNA_8 DNA_9 DNA_10 DNA_11 DNA_12 DNA_13
+  DNA_14 DNA_15 DNB_0 DNB_1 DNB_2 DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 DNB_8 DNB_9
+  DNB_10 DNB_11 DNB_12 DNB_13 DNB_14 DNB_15 EMA0_0 EMA0_1 EMA1_0 EMA1_1
+  EMA2_0 EMA2_1 GDLA_0 GDLA_1 GDLA_2 GDLA_3 GDLA_4 GDLA_5 GDLA_6 GDLA_7
+  GDLA_8 GDLA_9 GDLA_10 GDLA_11 GDLA_12 GDLA_13 GDLA_14 GDLA_15 GDLA_16
+  GDLA_17 GDLA_18 GDLA_19 GDLA_20 GDLA_21 GDLA_22 GDLA_23 GDLA_24 GDLA_25
+  GDLA_26 GDLA_27 GDLA_28 GDLA_29 GDLA_30 GDLA_31 GDLA_32 GDLA_33 GDLA_34
+  GDLA_35 GDLA_36 GDLA_37 GDLA_38 GDLA_39 GDLA_40 GDLA_41 GDLA_42 GDLA_43
+  GDLA_44 GDLA_45 GDLA_46 GDLA_47 GDLA_48 GDLA_49 GDLA_50 GDLA_51 GDLA_52
+  GDLA_53 GDLA_54 GDLA_55 GDLA_56 GDLA_57 GDLA_58 GDLA_59 GDLA_60 GDLA_61
+  GDLA_62 GDLA_63 GDLA__0 GDLA__1 GDLA__2 GDLA__3 GDLA__4 GDLA__5 GDLA__6
+  GDLA__7 GDLA__8 GDLA__9 GDLA__10 GDLA__11 GDLA__12 GDLA__13 GDLA__14
+  GDLA__15 GDLA__16 GDLA__17 GDLA__18 GDLA__19 GDLA__20 GDLA__21 GDLA__22
+  GDLA__23 GDLA__24 GDLA__25 GDLA__26 GDLA__27 GDLA__28 GDLA__29 GDLA__30
+  GDLA__31 GDLA__32 GDLA__33 GDLA__34 GDLA__35 GDLA__36 GDLA__37 GDLA__38
+  GDLA__39 GDLA__40 GDLA__41 GDLA__42 GDLA__43 GDLA__44 GDLA__45 GDLA__46
+  GDLA__47 GDLA__48 GDLA__49 GDLA__50 GDLA__51 GDLA__52 GDLA__53 GDLA__54
+  GDLA__55 GDLA__56 GDLA__57 GDLA__58 GDLA__59 GDLA__60 GDLA__61 GDLA__62
+  GDLA__63 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6 GDLB_7 GDLB_8
+  GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15 GDLB_16 GDLB_17
+  GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23 GDLB_24 GDLB_25 GDLB_26
+  GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB_32 GDLB_33 GDLB_34 GDLB_35
+  GDLB_36 GDLB_37 GDLB_38 GDLB_39 GDLB_40 GDLB_41 GDLB_42 GDLB_43 GDLB_44
+  GDLB_45 GDLB_46 GDLB_47 GDLB_48 GDLB_49 GDLB_50 GDLB_51 GDLB_52 GDLB_53
+  GDLB_54 GDLB_55 GDLB_56 GDLB_57 GDLB_58 GDLB_59 GDLB_60 GDLB_61 GDLB_62
+  GDLB_63 GDLB__0 GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6 GDLB__7
+  GDLB__8 GDLB__9 GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14 GDLB__15
+  GDLB__16 GDLB__17 GDLB__18 GDLB__19 GDLB__20 GDLB__21 GDLB__22 GDLB__23
+  GDLB__24 GDLB__25 GDLB__26 GDLB__27 GDLB__28 GDLB__29 GDLB__30 GDLB__31
+  GDLB__32 GDLB__33 GDLB__34 GDLB__35 GDLB__36 GDLB__37 GDLB__38 GDLB__39
+  GDLB__40 GDLB__41 GDLB__42 GDLB__43 GDLB__44 GDLB__45 GDLB__46 GDLB__47
+  GDLB__48 GDLB__49 GDLB__50 GDLB__51 GDLB__52 GDLB__53 GDLB__54 GDLB__55
+  GDLB__56 GDLB__57 GDLB__58 GDLB__59 GDLB__60 GDLB__61 GDLB__62 GDLB__63
+  GTPDE_0 GTPDE_1 GTPDS_0 GTPDS_1 GTP_0 GTP_1 GWEI_0 GWEI_1 IRET_0 IRET_1
+  LGWE_0 LGWE_1 MBL_0 MBL_1 MGDLE_0 MGDLE_1 MGDLS_0 MGDLS_1 MGTPS_0 MGTPS_1
+  ORET_0 ORET_1 PRDT_0 PRDT_1 PRRA0N_0 PRRA0N_1 PRRA1N_0 PRRA1N_1 PWBT_0
+  PWBT_1 QA__0 QA__1 QA__2 QA__3 QA__4 QA__5 QA__6 QA__7 QA__8 QA__9 QA__10
+  QA__11 QA__12 QA__13 QA__14 QA__15 QB__0 QB__1 QB__2 QB__3 QB__4 QB__5
+  QB__6 QB__7 QB__8 QB__9 QB__10 QB__11 QB__12 QB__13 QB__14 QB__15 RDTN_0
+  RDTN_1 RET RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0 RRA1_1 RRA1__0 RRA1__1
+  RREN_0 RREN_1 STOV_0 STOV_1 STUB_BLA0_0 STUB_BLA0_1 STUB_BLA0_2 STUB_BLA0_3
+  STUB_BLA0_4 STUB_BLA0_5 STUB_BLA0_6 STUB_BLA0_7 STUB_BLA0_8 STUB_BLA0_9
+  STUB_BLA0_10 STUB_BLA0_11 STUB_BLA0_12 STUB_BLA0_13 STUB_BLA0_14
+  STUB_BLA0_15 STUB_BLA0_16 STUB_BLA0_17 STUB_BLA0_18 STUB_BLA0_19
+  STUB_BLA0_20 STUB_BLA0_21 STUB_BLA0_22 STUB_BLA0_23 STUB_BLA0_24
+  STUB_BLA0_25 STUB_BLA0_26 STUB_BLA0_27 STUB_BLA0_28 STUB_BLA0_29
+  STUB_BLA0_30 STUB_BLA0_31 STUB_BLA0_32 STUB_BLA0_33 STUB_BLA0_34
+  STUB_BLA0_35 STUB_BLA0_36 STUB_BLA0_37 STUB_BLA0_38 STUB_BLA0_39
+  STUB_BLA0_40 STUB_BLA0_41 STUB_BLA0_42 STUB_BLA0_43 STUB_BLA0_44
+  STUB_BLA0_45 STUB_BLA0_46 STUB_BLA0_47 STUB_BLA0_48 STUB_BLA0_49
+  STUB_BLA0_50 STUB_BLA0_51 STUB_BLA0_52 STUB_BLA0_53 STUB_BLA0_54
+  STUB_BLA0_55 STUB_BLA0_56 STUB_BLA0_57 STUB_BLA0_58 STUB_BLA0_59
+  STUB_BLA0_60 STUB_BLA0_61 STUB_BLA0_62 STUB_BLA0_63 STUB_BLA0__0
+  STUB_BLA0__1 STUB_BLA0__2 STUB_BLA0__3 STUB_BLA0__4 STUB_BLA0__5
+  STUB_BLA0__6 STUB_BLA0__7 STUB_BLA0__8 STUB_BLA0__9 STUB_BLA0__10
+  STUB_BLA0__11 STUB_BLA0__12 STUB_BLA0__13 STUB_BLA0__14 STUB_BLA0__15
+  STUB_BLA0__16 STUB_BLA0__17 STUB_BLA0__18 STUB_BLA0__19 STUB_BLA0__20
+  STUB_BLA0__21 STUB_BLA0__22 STUB_BLA0__23 STUB_BLA0__24 STUB_BLA0__25
+  STUB_BLA0__26 STUB_BLA0__27 STUB_BLA0__28 STUB_BLA0__29 STUB_BLA0__30
+  STUB_BLA0__31 STUB_BLA0__32 STUB_BLA0__33 STUB_BLA0__34 STUB_BLA0__35
+  STUB_BLA0__36 STUB_BLA0__37 STUB_BLA0__38 STUB_BLA0__39 STUB_BLA0__40
+  STUB_BLA0__41 STUB_BLA0__42 STUB_BLA0__43 STUB_BLA0__44 STUB_BLA0__45
+  STUB_BLA0__46 STUB_BLA0__47 STUB_BLA0__48 STUB_BLA0__49 STUB_BLA0__50
+  STUB_BLA0__51 STUB_BLA0__52 STUB_BLA0__53 STUB_BLA0__54 STUB_BLA0__55
+  STUB_BLA0__56 STUB_BLA0__57 STUB_BLA0__58 STUB_BLA0__59 STUB_BLA0__60
+  STUB_BLA0__61 STUB_BLA0__62 STUB_BLA0__63 STUB_BLA1_0 STUB_BLA1_1
+  STUB_BLA1_2 STUB_BLA1_3 STUB_BLA1_4 STUB_BLA1_5 STUB_BLA1_6 STUB_BLA1_7
+  STUB_BLA1_8 STUB_BLA1_9 STUB_BLA1_10 STUB_BLA1_11 STUB_BLA1_12 STUB_BLA1_13
+  STUB_BLA1_14 STUB_BLA1_15 STUB_BLA1_16 STUB_BLA1_17 STUB_BLA1_18
+  STUB_BLA1_19 STUB_BLA1_20 STUB_BLA1_21 STUB_BLA1_22 STUB_BLA1_23
+  STUB_BLA1_24 STUB_BLA1_25 STUB_BLA1_26 STUB_BLA1_27 STUB_BLA1_28
+  STUB_BLA1_29 STUB_BLA1_30 STUB_BLA1_31 STUB_BLA1_32 STUB_BLA1_33
+  STUB_BLA1_34 STUB_BLA1_35 STUB_BLA1_36 STUB_BLA1_37 STUB_BLA1_38
+  STUB_BLA1_39 STUB_BLA1_40 STUB_BLA1_41 STUB_BLA1_42 STUB_BLA1_43
+  STUB_BLA1_44 STUB_BLA1_45 STUB_BLA1_46 STUB_BLA1_47 STUB_BLA1_48
+  STUB_BLA1_49 STUB_BLA1_50 STUB_BLA1_51 STUB_BLA1_52 STUB_BLA1_53
+  STUB_BLA1_54 STUB_BLA1_55 STUB_BLA1_56 STUB_BLA1_57 STUB_BLA1_58
+  STUB_BLA1_59 STUB_BLA1_60 STUB_BLA1_61 STUB_BLA1_62 STUB_BLA1_63
+  STUB_BLA1__0 STUB_BLA1__1 STUB_BLA1__2 STUB_BLA1__3 STUB_BLA1__4
+  STUB_BLA1__5 STUB_BLA1__6 STUB_BLA1__7 STUB_BLA1__8 STUB_BLA1__9
+  STUB_BLA1__10 STUB_BLA1__11 STUB_BLA1__12 STUB_BLA1__13 STUB_BLA1__14
+  STUB_BLA1__15 STUB_BLA1__16 STUB_BLA1__17 STUB_BLA1__18 STUB_BLA1__19
+  STUB_BLA1__20 STUB_BLA1__21 STUB_BLA1__22 STUB_BLA1__23 STUB_BLA1__24
+  STUB_BLA1__25 STUB_BLA1__26 STUB_BLA1__27 STUB_BLA1__28 STUB_BLA1__29
+  STUB_BLA1__30 STUB_BLA1__31 STUB_BLA1__32 STUB_BLA1__33 STUB_BLA1__34
+  STUB_BLA1__35 STUB_BLA1__36 STUB_BLA1__37 STUB_BLA1__38 STUB_BLA1__39
+  STUB_BLA1__40 STUB_BLA1__41 STUB_BLA1__42 STUB_BLA1__43 STUB_BLA1__44
+  STUB_BLA1__45 STUB_BLA1__46 STUB_BLA1__47 STUB_BLA1__48 STUB_BLA1__49
+  STUB_BLA1__50 STUB_BLA1__51 STUB_BLA1__52 STUB_BLA1__53 STUB_BLA1__54
+  STUB_BLA1__55 STUB_BLA1__56 STUB_BLA1__57 STUB_BLA1__58 STUB_BLA1__59
+  STUB_BLA1__60 STUB_BLA1__61 STUB_BLA1__62 STUB_BLA1__63 STUB_BLA2_0
+  STUB_BLA2_1 STUB_BLA2_2 STUB_BLA2_3 STUB_BLA2_4 STUB_BLA2_5 STUB_BLA2_6
+  STUB_BLA2_7 STUB_BLA2_8 STUB_BLA2_9 STUB_BLA2_10 STUB_BLA2_11 STUB_BLA2_12
+  STUB_BLA2_13 STUB_BLA2_14 STUB_BLA2_15 STUB_BLA2_16 STUB_BLA2_17
+  STUB_BLA2_18 STUB_BLA2_19 STUB_BLA2_20 STUB_BLA2_21 STUB_BLA2_22
+  STUB_BLA2_23 STUB_BLA2_24 STUB_BLA2_25 STUB_BLA2_26 STUB_BLA2_27
+  STUB_BLA2_28 STUB_BLA2_29 STUB_BLA2_30 STUB_BLA2_31 STUB_BLA2_32
+  STUB_BLA2_33 STUB_BLA2_34 STUB_BLA2_35 STUB_BLA2_36 STUB_BLA2_37
+  STUB_BLA2_38 STUB_BLA2_39 STUB_BLA2_40 STUB_BLA2_41 STUB_BLA2_42
+  STUB_BLA2_43 STUB_BLA2_44 STUB_BLA2_45 STUB_BLA2_46 STUB_BLA2_47
+  STUB_BLA2_48 STUB_BLA2_49 STUB_BLA2_50 STUB_BLA2_51 STUB_BLA2_52
+  STUB_BLA2_53 STUB_BLA2_54 STUB_BLA2_55 STUB_BLA2_56 STUB_BLA2_57
+  STUB_BLA2_58 STUB_BLA2_59 STUB_BLA2_60 STUB_BLA2_61 STUB_BLA2_62
+  STUB_BLA2_63 STUB_BLA2__0 STUB_BLA2__1 STUB_BLA2__2 STUB_BLA2__3
+  STUB_BLA2__4 STUB_BLA2__5 STUB_BLA2__6 STUB_BLA2__7 STUB_BLA2__8
+  STUB_BLA2__9 STUB_BLA2__10 STUB_BLA2__11 STUB_BLA2__12 STUB_BLA2__13
+  STUB_BLA2__14 STUB_BLA2__15 STUB_BLA2__16 STUB_BLA2__17 STUB_BLA2__18
+  STUB_BLA2__19 STUB_BLA2__20 STUB_BLA2__21 STUB_BLA2__22 STUB_BLA2__23
+  STUB_BLA2__24 STUB_BLA2__25 STUB_BLA2__26 STUB_BLA2__27 STUB_BLA2__28
+  STUB_BLA2__29 STUB_BLA2__30 STUB_BLA2__31 STUB_BLA2__32 STUB_BLA2__33
+  STUB_BLA2__34 STUB_BLA2__35 STUB_BLA2__36 STUB_BLA2__37 STUB_BLA2__38
+  STUB_BLA2__39 STUB_BLA2__40 STUB_BLA2__41 STUB_BLA2__42 STUB_BLA2__43
+  STUB_BLA2__44 STUB_BLA2__45 STUB_BLA2__46 STUB_BLA2__47 STUB_BLA2__48
+  STUB_BLA2__49 STUB_BLA2__50 STUB_BLA2__51 STUB_BLA2__52 STUB_BLA2__53
+  STUB_BLA2__54 STUB_BLA2__55 STUB_BLA2__56 STUB_BLA2__57 STUB_BLA2__58
+  STUB_BLA2__59 STUB_BLA2__60 STUB_BLA2__61 STUB_BLA2__62 STUB_BLA2__63
+  STUB_BLA3_0 STUB_BLA3_1 STUB_BLA3_2 STUB_BLA3_3 STUB_BLA3_4 STUB_BLA3_5
+  STUB_BLA3_6 STUB_BLA3_7 STUB_BLA3_8 STUB_BLA3_9 STUB_BLA3_10 STUB_BLA3_11
+  STUB_BLA3_12 STUB_BLA3_13 STUB_BLA3_14 STUB_BLA3_15 STUB_BLA3_16
+  STUB_BLA3_17 STUB_BLA3_18 STUB_BLA3_19 STUB_BLA3_20 STUB_BLA3_21
+  STUB_BLA3_22 STUB_BLA3_23 STUB_BLA3_24 STUB_BLA3_25 STUB_BLA3_26
+  STUB_BLA3_27 STUB_BLA3_28 STUB_BLA3_29 STUB_BLA3_30 STUB_BLA3_31
+  STUB_BLA3_32 STUB_BLA3_33 STUB_BLA3_34 STUB_BLA3_35 STUB_BLA3_36
+  STUB_BLA3_37 STUB_BLA3_38 STUB_BLA3_39 STUB_BLA3_40 STUB_BLA3_41
+  STUB_BLA3_42 STUB_BLA3_43 STUB_BLA3_44 STUB_BLA3_45 STUB_BLA3_46
+  STUB_BLA3_47 STUB_BLA3_48 STUB_BLA3_49 STUB_BLA3_50 STUB_BLA3_51
+  STUB_BLA3_52 STUB_BLA3_53 STUB_BLA3_54 STUB_BLA3_55 STUB_BLA3_56
+  STUB_BLA3_57 STUB_BLA3_58 STUB_BLA3_59 STUB_BLA3_60 STUB_BLA3_61
+  STUB_BLA3_62 STUB_BLA3_63 STUB_BLA3__0 STUB_BLA3__1 STUB_BLA3__2
+  STUB_BLA3__3 STUB_BLA3__4 STUB_BLA3__5 STUB_BLA3__6 STUB_BLA3__7
+  STUB_BLA3__8 STUB_BLA3__9 STUB_BLA3__10 STUB_BLA3__11 STUB_BLA3__12
+  STUB_BLA3__13 STUB_BLA3__14 STUB_BLA3__15 STUB_BLA3__16 STUB_BLA3__17
+  STUB_BLA3__18 STUB_BLA3__19 STUB_BLA3__20 STUB_BLA3__21 STUB_BLA3__22
+  STUB_BLA3__23 STUB_BLA3__24 STUB_BLA3__25 STUB_BLA3__26 STUB_BLA3__27
+  STUB_BLA3__28 STUB_BLA3__29 STUB_BLA3__30 STUB_BLA3__31 STUB_BLA3__32
+  STUB_BLA3__33 STUB_BLA3__34 STUB_BLA3__35 STUB_BLA3__36 STUB_BLA3__37
+  STUB_BLA3__38 STUB_BLA3__39 STUB_BLA3__40 STUB_BLA3__41 STUB_BLA3__42
+  STUB_BLA3__43 STUB_BLA3__44 STUB_BLA3__45 STUB_BLA3__46 STUB_BLA3__47
+  STUB_BLA3__48 STUB_BLA3__49 STUB_BLA3__50 STUB_BLA3__51 STUB_BLA3__52
+  STUB_BLA3__53 STUB_BLA3__54 STUB_BLA3__55 STUB_BLA3__56 STUB_BLA3__57
+  STUB_BLA3__58 STUB_BLA3__59 STUB_BLA3__60 STUB_BLA3__61 STUB_BLA3__62
+  STUB_BLA3__63 STUB_BLB0_0 STUB_BLB0_1 STUB_BLB0_2 STUB_BLB0_3 STUB_BLB0_4
+  STUB_BLB0_5 STUB_BLB0_6 STUB_BLB0_7 STUB_BLB0_8 STUB_BLB0_9 STUB_BLB0_10
+  STUB_BLB0_11 STUB_BLB0_12 STUB_BLB0_13 STUB_BLB0_14 STUB_BLB0_15
+  STUB_BLB0_16 STUB_BLB0_17 STUB_BLB0_18 STUB_BLB0_19 STUB_BLB0_20
+  STUB_BLB0_21 STUB_BLB0_22 STUB_BLB0_23 STUB_BLB0_24 STUB_BLB0_25
+  STUB_BLB0_26 STUB_BLB0_27 STUB_BLB0_28 STUB_BLB0_29 STUB_BLB0_30
+  STUB_BLB0_31 STUB_BLB0_32 STUB_BLB0_33 STUB_BLB0_34 STUB_BLB0_35
+  STUB_BLB0_36 STUB_BLB0_37 STUB_BLB0_38 STUB_BLB0_39 STUB_BLB0_40
+  STUB_BLB0_41 STUB_BLB0_42 STUB_BLB0_43 STUB_BLB0_44 STUB_BLB0_45
+  STUB_BLB0_46 STUB_BLB0_47 STUB_BLB0_48 STUB_BLB0_49 STUB_BLB0_50
+  STUB_BLB0_51 STUB_BLB0_52 STUB_BLB0_53 STUB_BLB0_54 STUB_BLB0_55
+  STUB_BLB0_56 STUB_BLB0_57 STUB_BLB0_58 STUB_BLB0_59 STUB_BLB0_60
+  STUB_BLB0_61 STUB_BLB0_62 STUB_BLB0_63 STUB_BLB0__0 STUB_BLB0__1
+  STUB_BLB0__2 STUB_BLB0__3 STUB_BLB0__4 STUB_BLB0__5 STUB_BLB0__6
+  STUB_BLB0__7 STUB_BLB0__8 STUB_BLB0__9 STUB_BLB0__10 STUB_BLB0__11
+  STUB_BLB0__12 STUB_BLB0__13 STUB_BLB0__14 STUB_BLB0__15 STUB_BLB0__16
+  STUB_BLB0__17 STUB_BLB0__18 STUB_BLB0__19 STUB_BLB0__20 STUB_BLB0__21
+  STUB_BLB0__22 STUB_BLB0__23 STUB_BLB0__24 STUB_BLB0__25 STUB_BLB0__26
+  STUB_BLB0__27 STUB_BLB0__28 STUB_BLB0__29 STUB_BLB0__30 STUB_BLB0__31
+  STUB_BLB0__32 STUB_BLB0__33 STUB_BLB0__34 STUB_BLB0__35 STUB_BLB0__36
+  STUB_BLB0__37 STUB_BLB0__38 STUB_BLB0__39 STUB_BLB0__40 STUB_BLB0__41
+  STUB_BLB0__42 STUB_BLB0__43 STUB_BLB0__44 STUB_BLB0__45 STUB_BLB0__46
+  STUB_BLB0__47 STUB_BLB0__48 STUB_BLB0__49 STUB_BLB0__50 STUB_BLB0__51
+  STUB_BLB0__52 STUB_BLB0__53 STUB_BLB0__54 STUB_BLB0__55 STUB_BLB0__56
+  STUB_BLB0__57 STUB_BLB0__58 STUB_BLB0__59 STUB_BLB0__60 STUB_BLB0__61
+  STUB_BLB0__62 STUB_BLB0__63 STUB_BLB1_0 STUB_BLB1_1 STUB_BLB1_2 STUB_BLB1_3
+  STUB_BLB1_4 STUB_BLB1_5 STUB_BLB1_6 STUB_BLB1_7 STUB_BLB1_8 STUB_BLB1_9
+  STUB_BLB1_10 STUB_BLB1_11 STUB_BLB1_12 STUB_BLB1_13 STUB_BLB1_14
+  STUB_BLB1_15 STUB_BLB1_16 STUB_BLB1_17 STUB_BLB1_18 STUB_BLB1_19
+  STUB_BLB1_20 STUB_BLB1_21 STUB_BLB1_22 STUB_BLB1_23 STUB_BLB1_24
+  STUB_BLB1_25 STUB_BLB1_26 STUB_BLB1_27 STUB_BLB1_28 STUB_BLB1_29
+  STUB_BLB1_30 STUB_BLB1_31 STUB_BLB1_32 STUB_BLB1_33 STUB_BLB1_34
+  STUB_BLB1_35 STUB_BLB1_36 STUB_BLB1_37 STUB_BLB1_38 STUB_BLB1_39
+  STUB_BLB1_40 STUB_BLB1_41 STUB_BLB1_42 STUB_BLB1_43 STUB_BLB1_44
+  STUB_BLB1_45 STUB_BLB1_46 STUB_BLB1_47 STUB_BLB1_48 STUB_BLB1_49
+  STUB_BLB1_50 STUB_BLB1_51 STUB_BLB1_52 STUB_BLB1_53 STUB_BLB1_54
+  STUB_BLB1_55 STUB_BLB1_56 STUB_BLB1_57 STUB_BLB1_58 STUB_BLB1_59
+  STUB_BLB1_60 STUB_BLB1_61 STUB_BLB1_62 STUB_BLB1_63 STUB_BLB1__0
+  STUB_BLB1__1 STUB_BLB1__2 STUB_BLB1__3 STUB_BLB1__4 STUB_BLB1__5
+  STUB_BLB1__6 STUB_BLB1__7 STUB_BLB1__8 STUB_BLB1__9 STUB_BLB1__10
+  STUB_BLB1__11 STUB_BLB1__12 STUB_BLB1__13 STUB_BLB1__14 STUB_BLB1__15
+  STUB_BLB1__16 STUB_BLB1__17 STUB_BLB1__18 STUB_BLB1__19 STUB_BLB1__20
+  STUB_BLB1__21 STUB_BLB1__22 STUB_BLB1__23 STUB_BLB1__24 STUB_BLB1__25
+  STUB_BLB1__26 STUB_BLB1__27 STUB_BLB1__28 STUB_BLB1__29 STUB_BLB1__30
+  STUB_BLB1__31 STUB_BLB1__32 STUB_BLB1__33 STUB_BLB1__34 STUB_BLB1__35
+  STUB_BLB1__36 STUB_BLB1__37 STUB_BLB1__38 STUB_BLB1__39 STUB_BLB1__40
+  STUB_BLB1__41 STUB_BLB1__42 STUB_BLB1__43 STUB_BLB1__44 STUB_BLB1__45
+  STUB_BLB1__46 STUB_BLB1__47 STUB_BLB1__48 STUB_BLB1__49 STUB_BLB1__50
+  STUB_BLB1__51 STUB_BLB1__52 STUB_BLB1__53 STUB_BLB1__54 STUB_BLB1__55
+  STUB_BLB1__56 STUB_BLB1__57 STUB_BLB1__58 STUB_BLB1__59 STUB_BLB1__60
+  STUB_BLB1__61 STUB_BLB1__62 STUB_BLB1__63 STUB_BLB2_0 STUB_BLB2_1
+  STUB_BLB2_2 STUB_BLB2_3 STUB_BLB2_4 STUB_BLB2_5 STUB_BLB2_6 STUB_BLB2_7
+  STUB_BLB2_8 STUB_BLB2_9 STUB_BLB2_10 STUB_BLB2_11 STUB_BLB2_12 STUB_BLB2_13
+  STUB_BLB2_14 STUB_BLB2_15 STUB_BLB2_16 STUB_BLB2_17 STUB_BLB2_18
+  STUB_BLB2_19 STUB_BLB2_20 STUB_BLB2_21 STUB_BLB2_22 STUB_BLB2_23
+  STUB_BLB2_24 STUB_BLB2_25 STUB_BLB2_26 STUB_BLB2_27 STUB_BLB2_28
+  STUB_BLB2_29 STUB_BLB2_30 STUB_BLB2_31 STUB_BLB2_32 STUB_BLB2_33
+  STUB_BLB2_34 STUB_BLB2_35 STUB_BLB2_36 STUB_BLB2_37 STUB_BLB2_38
+  STUB_BLB2_39 STUB_BLB2_40 STUB_BLB2_41 STUB_BLB2_42 STUB_BLB2_43
+  STUB_BLB2_44 STUB_BLB2_45 STUB_BLB2_46 STUB_BLB2_47 STUB_BLB2_48
+  STUB_BLB2_49 STUB_BLB2_50 STUB_BLB2_51 STUB_BLB2_52 STUB_BLB2_53
+  STUB_BLB2_54 STUB_BLB2_55 STUB_BLB2_56 STUB_BLB2_57 STUB_BLB2_58
+  STUB_BLB2_59 STUB_BLB2_60 STUB_BLB2_61 STUB_BLB2_62 STUB_BLB2_63
+  STUB_BLB2__0 STUB_BLB2__1 STUB_BLB2__2 STUB_BLB2__3 STUB_BLB2__4
+  STUB_BLB2__5 STUB_BLB2__6 STUB_BLB2__7 STUB_BLB2__8 STUB_BLB2__9
+  STUB_BLB2__10 STUB_BLB2__11 STUB_BLB2__12 STUB_BLB2__13 STUB_BLB2__14
+  STUB_BLB2__15 STUB_BLB2__16 STUB_BLB2__17 STUB_BLB2__18 STUB_BLB2__19
+  STUB_BLB2__20 STUB_BLB2__21 STUB_BLB2__22 STUB_BLB2__23 STUB_BLB2__24
+  STUB_BLB2__25 STUB_BLB2__26 STUB_BLB2__27 STUB_BLB2__28 STUB_BLB2__29
+  STUB_BLB2__30 STUB_BLB2__31 STUB_BLB2__32 STUB_BLB2__33 STUB_BLB2__34
+  STUB_BLB2__35 STUB_BLB2__36 STUB_BLB2__37 STUB_BLB2__38 STUB_BLB2__39
+  STUB_BLB2__40 STUB_BLB2__41 STUB_BLB2__42 STUB_BLB2__43 STUB_BLB2__44
+  STUB_BLB2__45 STUB_BLB2__46 STUB_BLB2__47 STUB_BLB2__48 STUB_BLB2__49
+  STUB_BLB2__50 STUB_BLB2__51 STUB_BLB2__52 STUB_BLB2__53 STUB_BLB2__54
+  STUB_BLB2__55 STUB_BLB2__56 STUB_BLB2__57 STUB_BLB2__58 STUB_BLB2__59
+  STUB_BLB2__60 STUB_BLB2__61 STUB_BLB2__62 STUB_BLB2__63 STUB_BLB3_0
+  STUB_BLB3_1 STUB_BLB3_2 STUB_BLB3_3 STUB_BLB3_4 STUB_BLB3_5 STUB_BLB3_6
+  STUB_BLB3_7 STUB_BLB3_8 STUB_BLB3_9 STUB_BLB3_10 STUB_BLB3_11 STUB_BLB3_12
+  STUB_BLB3_13 STUB_BLB3_14 STUB_BLB3_15 STUB_BLB3_16 STUB_BLB3_17
+  STUB_BLB3_18 STUB_BLB3_19 STUB_BLB3_20 STUB_BLB3_21 STUB_BLB3_22
+  STUB_BLB3_23 STUB_BLB3_24 STUB_BLB3_25 STUB_BLB3_26 STUB_BLB3_27
+  STUB_BLB3_28 STUB_BLB3_29 STUB_BLB3_30 STUB_BLB3_31 STUB_BLB3_32
+  STUB_BLB3_33 STUB_BLB3_34 STUB_BLB3_35 STUB_BLB3_36 STUB_BLB3_37
+  STUB_BLB3_38 STUB_BLB3_39 STUB_BLB3_40 STUB_BLB3_41 STUB_BLB3_42
+  STUB_BLB3_43 STUB_BLB3_44 STUB_BLB3_45 STUB_BLB3_46 STUB_BLB3_47
+  STUB_BLB3_48 STUB_BLB3_49 STUB_BLB3_50 STUB_BLB3_51 STUB_BLB3_52
+  STUB_BLB3_53 STUB_BLB3_54 STUB_BLB3_55 STUB_BLB3_56 STUB_BLB3_57
+  STUB_BLB3_58 STUB_BLB3_59 STUB_BLB3_60 STUB_BLB3_61 STUB_BLB3_62
+  STUB_BLB3_63 STUB_BLB3__0 STUB_BLB3__1 STUB_BLB3__2 STUB_BLB3__3
+  STUB_BLB3__4 STUB_BLB3__5 STUB_BLB3__6 STUB_BLB3__7 STUB_BLB3__8
+  STUB_BLB3__9 STUB_BLB3__10 STUB_BLB3__11 STUB_BLB3__12 STUB_BLB3__13
+  STUB_BLB3__14 STUB_BLB3__15 STUB_BLB3__16 STUB_BLB3__17 STUB_BLB3__18
+  STUB_BLB3__19 STUB_BLB3__20 STUB_BLB3__21 STUB_BLB3__22 STUB_BLB3__23
+  STUB_BLB3__24 STUB_BLB3__25 STUB_BLB3__26 STUB_BLB3__27 STUB_BLB3__28
+  STUB_BLB3__29 STUB_BLB3__30 STUB_BLB3__31 STUB_BLB3__32 STUB_BLB3__33
+  STUB_BLB3__34 STUB_BLB3__35 STUB_BLB3__36 STUB_BLB3__37 STUB_BLB3__38
+  STUB_BLB3__39 STUB_BLB3__40 STUB_BLB3__41 STUB_BLB3__42 STUB_BLB3__43
+  STUB_BLB3__44 STUB_BLB3__45 STUB_BLB3__46 STUB_BLB3__47 STUB_BLB3__48
+  STUB_BLB3__49 STUB_BLB3__50 STUB_BLB3__51 STUB_BLB3__52 STUB_BLB3__53
+  STUB_BLB3__54 STUB_BLB3__55 STUB_BLB3__56 STUB_BLB3__57 STUB_BLB3__58
+  STUB_BLB3__59 STUB_BLB3__60 STUB_BLB3__61 STUB_BLB3__62 STUB_BLB3__63
+  TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 WBT_0 WBT_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpGCTRL_ROW: 14904 flat devices **
XI0_0 BWEIA_7 BWEIA_6 BWEIA_5 BWEIA_4 BWEIA_3 BWEIA_2 BWEIA_1 BWEIA_0 BWEIB_7
+  BWEIB_6 BWEIB_5 BWEIB_4 BWEIB_3 BWEIB_2 BWEIB_1 BWEIB_0 TIEHI_0 DNA_7 DNA_6
+  DNA_5 DNA_4 DNA_3 DNA_2 DNA_1 DNA_0 DNB_7 DNB_6 DNB_5 DNB_4 DNB_3 DNB_2
+  DNB_1 DNB_0 FIOBTPA FIOBTPB GDLA_31 GDLA_30 GDLA_29 GDLA_28 GDLA_27 GDLA_26
+  GDLA_25 GDLA_24 GDLA_23 GDLA_22 GDLA_21 GDLA_20 GDLA_19 GDLA_18 GDLA_17
+  GDLA_16 GDLA_15 GDLA_14 GDLA_13 GDLA_12 GDLA_11 GDLA_10 GDLA_9 GDLA_8
+  GDLA_7 GDLA_6 GDLA_5 GDLA_4 GDLA_3 GDLA_2 GDLA_1 GDLA_0 GDLA__31 GDLA__30
+  GDLA__29 GDLA__28 GDLA__27 GDLA__26 GDLA__25 GDLA__24 GDLA__23 GDLA__22
+  GDLA__21 GDLA__20 GDLA__19 GDLA__18 GDLA__17 GDLA__16 GDLA__15 GDLA__14
+  GDLA__13 GDLA__12 GDLA__11 GDLA__10 GDLA__9 GDLA__8 GDLA__7 GDLA__6 GDLA__5
+  GDLA__4 GDLA__3 GDLA__2 GDLA__1 GDLA__0 GDLB_31 GDLB_30 GDLB_29 GDLB_28
+  GDLB_27 GDLB_26 GDLB_25 GDLB_24 GDLB_23 GDLB_22 GDLB_21 GDLB_20 GDLB_19
+  GDLB_18 GDLB_17 GDLB_16 GDLB_15 GDLB_14 GDLB_13 GDLB_12 GDLB_11 GDLB_10
+  GDLB_9 GDLB_8 GDLB_7 GDLB_6 GDLB_5 GDLB_4 GDLB_3 GDLB_2 GDLB_1 GDLB_0
+  GDLB__31 GDLB__30 GDLB__29 GDLB__28 GDLB__27 GDLB__26 GDLB__25 GDLB__24
+  GDLB__23 GDLB__22 GDLB__21 GDLB__20 GDLB__19 GDLB__18 GDLB__17 GDLB__16
+  GDLB__15 GDLB__14 GDLB__13 GDLB__12 GDLB__11 GDLB__10 GDLB__9 GDLB__8
+  GDLB__7 GDLB__6 GDLB__5 GDLB__4 GDLB__3 GDLB__2 GDLB__1 GDLB__0 IOBTPA
+  IOBTPB IRET_0 ORET_0 QA__7 QA__6 QA__5 QA__4 QA__3 QA__2 QA__1 QA__0 QB__7
+  QB__6 QB__5 QB__4 QB__3 QB__2 QB__1 QB__0 STUB_BLA0_31 STUB_BLA0_30
+  STUB_BLA0_29 STUB_BLA0_28 STUB_BLA0_27 STUB_BLA0_26 STUB_BLA0_25
+  STUB_BLA0_24 STUB_BLA0_23 STUB_BLA0_22 STUB_BLA0_21 STUB_BLA0_20
+  STUB_BLA0_19 STUB_BLA0_18 STUB_BLA0_17 STUB_BLA0_16 STUB_BLA0_15
+  STUB_BLA0_14 STUB_BLA0_13 STUB_BLA0_12 STUB_BLA0_11 STUB_BLA0_10
+  STUB_BLA0_9 STUB_BLA0_8 STUB_BLA0_7 STUB_BLA0_6 STUB_BLA0_5 STUB_BLA0_4
+  STUB_BLA0_3 STUB_BLA0_2 STUB_BLA0_1 STUB_BLA0_0 STUB_BLA0__31 STUB_BLA0__30
+  STUB_BLA0__29 STUB_BLA0__28 STUB_BLA0__27 STUB_BLA0__26 STUB_BLA0__25
+  STUB_BLA0__24 STUB_BLA0__23 STUB_BLA0__22 STUB_BLA0__21 STUB_BLA0__20
+  STUB_BLA0__19 STUB_BLA0__18 STUB_BLA0__17 STUB_BLA0__16 STUB_BLA0__15
+  STUB_BLA0__14 STUB_BLA0__13 STUB_BLA0__12 STUB_BLA0__11 STUB_BLA0__10
+  STUB_BLA0__9 STUB_BLA0__8 STUB_BLA0__7 STUB_BLA0__6 STUB_BLA0__5
+  STUB_BLA0__4 STUB_BLA0__3 STUB_BLA0__2 STUB_BLA0__1 STUB_BLA0__0
+  STUB_BLA1_31 STUB_BLA1_30 STUB_BLA1_29 STUB_BLA1_28 STUB_BLA1_27
+  STUB_BLA1_26 STUB_BLA1_25 STUB_BLA1_24 STUB_BLA1_23 STUB_BLA1_22
+  STUB_BLA1_21 STUB_BLA1_20 STUB_BLA1_19 STUB_BLA1_18 STUB_BLA1_17
+  STUB_BLA1_16 STUB_BLA1_15 STUB_BLA1_14 STUB_BLA1_13 STUB_BLA1_12
+  STUB_BLA1_11 STUB_BLA1_10 STUB_BLA1_9 STUB_BLA1_8 STUB_BLA1_7 STUB_BLA1_6
+  STUB_BLA1_5 STUB_BLA1_4 STUB_BLA1_3 STUB_BLA1_2 STUB_BLA1_1 STUB_BLA1_0
+  STUB_BLA1__31 STUB_BLA1__30 STUB_BLA1__29 STUB_BLA1__28 STUB_BLA1__27
+  STUB_BLA1__26 STUB_BLA1__25 STUB_BLA1__24 STUB_BLA1__23 STUB_BLA1__22
+  STUB_BLA1__21 STUB_BLA1__20 STUB_BLA1__19 STUB_BLA1__18 STUB_BLA1__17
+  STUB_BLA1__16 STUB_BLA1__15 STUB_BLA1__14 STUB_BLA1__13 STUB_BLA1__12
+  STUB_BLA1__11 STUB_BLA1__10 STUB_BLA1__9 STUB_BLA1__8 STUB_BLA1__7
+  STUB_BLA1__6 STUB_BLA1__5 STUB_BLA1__4 STUB_BLA1__3 STUB_BLA1__2
+  STUB_BLA1__1 STUB_BLA1__0 STUB_BLA2_31 STUB_BLA2_30 STUB_BLA2_29
+  STUB_BLA2_28 STUB_BLA2_27 STUB_BLA2_26 STUB_BLA2_25 STUB_BLA2_24
+  STUB_BLA2_23 STUB_BLA2_22 STUB_BLA2_21 STUB_BLA2_20 STUB_BLA2_19
+  STUB_BLA2_18 STUB_BLA2_17 STUB_BLA2_16 STUB_BLA2_15 STUB_BLA2_14
+  STUB_BLA2_13 STUB_BLA2_12 STUB_BLA2_11 STUB_BLA2_10 STUB_BLA2_9 STUB_BLA2_8
+  STUB_BLA2_7 STUB_BLA2_6 STUB_BLA2_5 STUB_BLA2_4 STUB_BLA2_3 STUB_BLA2_2
+  STUB_BLA2_1 STUB_BLA2_0 STUB_BLA2__31 STUB_BLA2__30 STUB_BLA2__29
+  STUB_BLA2__28 STUB_BLA2__27 STUB_BLA2__26 STUB_BLA2__25 STUB_BLA2__24
+  STUB_BLA2__23 STUB_BLA2__22 STUB_BLA2__21 STUB_BLA2__20 STUB_BLA2__19
+  STUB_BLA2__18 STUB_BLA2__17 STUB_BLA2__16 STUB_BLA2__15 STUB_BLA2__14
+  STUB_BLA2__13 STUB_BLA2__12 STUB_BLA2__11 STUB_BLA2__10 STUB_BLA2__9
+  STUB_BLA2__8 STUB_BLA2__7 STUB_BLA2__6 STUB_BLA2__5 STUB_BLA2__4
+  STUB_BLA2__3 STUB_BLA2__2 STUB_BLA2__1 STUB_BLA2__0 STUB_BLA3_31
+  STUB_BLA3_30 STUB_BLA3_29 STUB_BLA3_28 STUB_BLA3_27 STUB_BLA3_26
+  STUB_BLA3_25 STUB_BLA3_24 STUB_BLA3_23 STUB_BLA3_22 STUB_BLA3_21
+  STUB_BLA3_20 STUB_BLA3_19 STUB_BLA3_18 STUB_BLA3_17 STUB_BLA3_16
+  STUB_BLA3_15 STUB_BLA3_14 STUB_BLA3_13 STUB_BLA3_12 STUB_BLA3_11
+  STUB_BLA3_10 STUB_BLA3_9 STUB_BLA3_8 STUB_BLA3_7 STUB_BLA3_6 STUB_BLA3_5
+  STUB_BLA3_4 STUB_BLA3_3 STUB_BLA3_2 STUB_BLA3_1 STUB_BLA3_0 STUB_BLA3__31
+  STUB_BLA3__30 STUB_BLA3__29 STUB_BLA3__28 STUB_BLA3__27 STUB_BLA3__26
+  STUB_BLA3__25 STUB_BLA3__24 STUB_BLA3__23 STUB_BLA3__22 STUB_BLA3__21
+  STUB_BLA3__20 STUB_BLA3__19 STUB_BLA3__18 STUB_BLA3__17 STUB_BLA3__16
+  STUB_BLA3__15 STUB_BLA3__14 STUB_BLA3__13 STUB_BLA3__12 STUB_BLA3__11
+  STUB_BLA3__10 STUB_BLA3__9 STUB_BLA3__8 STUB_BLA3__7 STUB_BLA3__6
+  STUB_BLA3__5 STUB_BLA3__4 STUB_BLA3__3 STUB_BLA3__2 STUB_BLA3__1
+  STUB_BLA3__0 STUB_BLB0_31 STUB_BLB0_30 STUB_BLB0_29 STUB_BLB0_28
+  STUB_BLB0_27 STUB_BLB0_26 STUB_BLB0_25 STUB_BLB0_24 STUB_BLB0_23
+  STUB_BLB0_22 STUB_BLB0_21 STUB_BLB0_20 STUB_BLB0_19 STUB_BLB0_18
+  STUB_BLB0_17 STUB_BLB0_16 STUB_BLB0_15 STUB_BLB0_14 STUB_BLB0_13
+  STUB_BLB0_12 STUB_BLB0_11 STUB_BLB0_10 STUB_BLB0_9 STUB_BLB0_8 STUB_BLB0_7
+  STUB_BLB0_6 STUB_BLB0_5 STUB_BLB0_4 STUB_BLB0_3 STUB_BLB0_2 STUB_BLB0_1
+  STUB_BLB0_0 STUB_BLB0__31 STUB_BLB0__30 STUB_BLB0__29 STUB_BLB0__28
+  STUB_BLB0__27 STUB_BLB0__26 STUB_BLB0__25 STUB_BLB0__24 STUB_BLB0__23
+  STUB_BLB0__22 STUB_BLB0__21 STUB_BLB0__20 STUB_BLB0__19 STUB_BLB0__18
+  STUB_BLB0__17 STUB_BLB0__16 STUB_BLB0__15 STUB_BLB0__14 STUB_BLB0__13
+  STUB_BLB0__12 STUB_BLB0__11 STUB_BLB0__10 STUB_BLB0__9 STUB_BLB0__8
+  STUB_BLB0__7 STUB_BLB0__6 STUB_BLB0__5 STUB_BLB0__4 STUB_BLB0__3
+  STUB_BLB0__2 STUB_BLB0__1 STUB_BLB0__0 STUB_BLB1_31 STUB_BLB1_30
+  STUB_BLB1_29 STUB_BLB1_28 STUB_BLB1_27 STUB_BLB1_26 STUB_BLB1_25
+  STUB_BLB1_24 STUB_BLB1_23 STUB_BLB1_22 STUB_BLB1_21 STUB_BLB1_20
+  STUB_BLB1_19 STUB_BLB1_18 STUB_BLB1_17 STUB_BLB1_16 STUB_BLB1_15
+  STUB_BLB1_14 STUB_BLB1_13 STUB_BLB1_12 STUB_BLB1_11 STUB_BLB1_10
+  STUB_BLB1_9 STUB_BLB1_8 STUB_BLB1_7 STUB_BLB1_6 STUB_BLB1_5 STUB_BLB1_4
+  STUB_BLB1_3 STUB_BLB1_2 STUB_BLB1_1 STUB_BLB1_0 STUB_BLB1__31 STUB_BLB1__30
+  STUB_BLB1__29 STUB_BLB1__28 STUB_BLB1__27 STUB_BLB1__26 STUB_BLB1__25
+  STUB_BLB1__24 STUB_BLB1__23 STUB_BLB1__22 STUB_BLB1__21 STUB_BLB1__20
+  STUB_BLB1__19 STUB_BLB1__18 STUB_BLB1__17 STUB_BLB1__16 STUB_BLB1__15
+  STUB_BLB1__14 STUB_BLB1__13 STUB_BLB1__12 STUB_BLB1__11 STUB_BLB1__10
+  STUB_BLB1__9 STUB_BLB1__8 STUB_BLB1__7 STUB_BLB1__6 STUB_BLB1__5
+  STUB_BLB1__4 STUB_BLB1__3 STUB_BLB1__2 STUB_BLB1__1 STUB_BLB1__0
+  STUB_BLB2_31 STUB_BLB2_30 STUB_BLB2_29 STUB_BLB2_28 STUB_BLB2_27
+  STUB_BLB2_26 STUB_BLB2_25 STUB_BLB2_24 STUB_BLB2_23 STUB_BLB2_22
+  STUB_BLB2_21 STUB_BLB2_20 STUB_BLB2_19 STUB_BLB2_18 STUB_BLB2_17
+  STUB_BLB2_16 STUB_BLB2_15 STUB_BLB2_14 STUB_BLB2_13 STUB_BLB2_12
+  STUB_BLB2_11 STUB_BLB2_10 STUB_BLB2_9 STUB_BLB2_8 STUB_BLB2_7 STUB_BLB2_6
+  STUB_BLB2_5 STUB_BLB2_4 STUB_BLB2_3 STUB_BLB2_2 STUB_BLB2_1 STUB_BLB2_0
+  STUB_BLB2__31 STUB_BLB2__30 STUB_BLB2__29 STUB_BLB2__28 STUB_BLB2__27
+  STUB_BLB2__26 STUB_BLB2__25 STUB_BLB2__24 STUB_BLB2__23 STUB_BLB2__22
+  STUB_BLB2__21 STUB_BLB2__20 STUB_BLB2__19 STUB_BLB2__18 STUB_BLB2__17
+  STUB_BLB2__16 STUB_BLB2__15 STUB_BLB2__14 STUB_BLB2__13 STUB_BLB2__12
+  STUB_BLB2__11 STUB_BLB2__10 STUB_BLB2__9 STUB_BLB2__8 STUB_BLB2__7
+  STUB_BLB2__6 STUB_BLB2__5 STUB_BLB2__4 STUB_BLB2__3 STUB_BLB2__2
+  STUB_BLB2__1 STUB_BLB2__0 STUB_BLB3_31 STUB_BLB3_30 STUB_BLB3_29
+  STUB_BLB3_28 STUB_BLB3_27 STUB_BLB3_26 STUB_BLB3_25 STUB_BLB3_24
+  STUB_BLB3_23 STUB_BLB3_22 STUB_BLB3_21 STUB_BLB3_20 STUB_BLB3_19
+  STUB_BLB3_18 STUB_BLB3_17 STUB_BLB3_16 STUB_BLB3_15 STUB_BLB3_14
+  STUB_BLB3_13 STUB_BLB3_12 STUB_BLB3_11 STUB_BLB3_10 STUB_BLB3_9 STUB_BLB3_8
+  STUB_BLB3_7 STUB_BLB3_6 STUB_BLB3_5 STUB_BLB3_4 STUB_BLB3_3 STUB_BLB3_2
+  STUB_BLB3_1 STUB_BLB3_0 STUB_BLB3__31 STUB_BLB3__30 STUB_BLB3__29
+  STUB_BLB3__28 STUB_BLB3__27 STUB_BLB3__26 STUB_BLB3__25 STUB_BLB3__24
+  STUB_BLB3__23 STUB_BLB3__22 STUB_BLB3__21 STUB_BLB3__20 STUB_BLB3__19
+  STUB_BLB3__18 STUB_BLB3__17 STUB_BLB3__16 STUB_BLB3__15 STUB_BLB3__14
+  STUB_BLB3__13 STUB_BLB3__12 STUB_BLB3__11 STUB_BLB3__10 STUB_BLB3__9
+  STUB_BLB3__8 STUB_BLB3__7 STUB_BLB3__6 STUB_BLB3__5 STUB_BLB3__4
+  STUB_BLB3__3 STUB_BLB3__2 STUB_BLB3__1 STUB_BLB3__0 TIELO_0 WEA WEB YP1_0_A
+  YP1_0_B YP1_1_A YP1_1_B YP1_2_A YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpIO_ROW_L
XI1_0 AI0N_0 AI1N_0 AI2N_0 AI3N_0 AI4N_0 AI5N_0 AI6N_0 AI7N_0 AI8N_0 AI9N_0
+  AI10N_0 AI11N_0 AI12N_0 AO4_0 AO5_0 AO6_0 AO7_0 AO8_0 AO9_0 AO10_0 AO11_0
+  AO12_0 AX0N_0 AX1N_0 AX2N_0 AX3N_0 AX4N_0 AX5N_0 AY0N_0 AY1N_0 AY2N_A
+  AY2N_B AY3N_A AY3N_B BS0N_0 BS1N_0 BS2N_0 CEI_0 CLK_0 EMA0_0 EMA1_0 EMA2_0
+  FIOBTPA FIOBTPB FIOGTPA FIOGTPB GTP_0 GTPDE_0 GTPDS_0 GWEI_0 GWENA GWENB
+  IOBTPA IOBTPB IOGTPNA IOGTPNB IRET_0 LGWE_0 MBL_0 MGDLE_0 MGDLS_0 MGTPS_0
+  ORET_0 PRDT_0 PRRA0N_0 PRRA1N_0 PWBT_0 RDTN_0 RET RRA0_0 RRA0__0 RRA1_0
+  RRA1__0 RREN_0 STOV_0 TIEHI_0 TIEHI_0 VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE TIEHI_0 TIELO_0 WBT_0 WEA WEB YP1_0_A YP1_0_B YP1_1_A YP1_1_B YP1_2_A
+  YP1_2_B YP1_3_A YP1_3_B VDDPE VDDCE VSSE pe_spad_1024x16_dpGCTRL_L
XI2_0 AI0N_1 AI1N_1 AI2N_1 AI3N_1 AI4N_1 AI5N_1 AI6N_1 AI7N_1 AI8N_1 AI9N_1
+  AI10N_1 AI11N_1 AI12N_1 AO4_1 AO5_1 AO6_1 AO7_1 AO8_1 AO9_1 AO10_1 AO11_1
+  AO12_1 AX0N_1 AX1N_1 AX2N_1 AX3N_1 AX4N_1 AX5N_1 AY0N_1 AY1N_1 AY2N_A
+  AY2N_B AY3N_A AY3N_B BS0N_1 BS1N_1 BS2N_1 CEI_1 CLK_1 EMA0_1 EMA1_1 EMA2_1
+  FIOBTPA_40 FIOBTPB_42 FIOGTPA FIOGTPB GTP_1 GTPDE_1 GTPDS_1 GWEI_1 GWENA
+  GWENB IOBTPA_44 IOBTPB_46 IOGTPNA IOGTPNB IRET_1 LGWE_1 MBL_1 MGDLE_1
+  MGDLS_1 MGTPS_1 ORET_1 PRDT_1 PRRA0N_1 PRRA1N_1 PWBT_1 RDTN_1 RET RRA0_1
+  RRA0__1 RRA1_1 RRA1__1 RREN_1 STOV_1 TIEHI_1 TIEHI_1 VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE TIEHI_1 TIELO_1 WBT_1 WEA_48 WEB_50 YP1_0_A_30
+  YP1_0_B_38 YP1_1_A_28 YP1_1_B_36 YP1_2_A_26 YP1_2_B_34 YP1_3_A_24
+  YP1_3_B_32 VDDPE VDDCE VSSE pe_spad_1024x16_dpGCTRL_R
XI3_0 BWEIA_8 BWEIA_9 BWEIA_10 BWEIA_11 BWEIA_12 BWEIA_13 BWEIA_14 BWEIA_15
+  BWEIB_8 BWEIB_9 BWEIB_10 BWEIB_11 BWEIB_12 BWEIB_13 BWEIB_14 BWEIB_15
+  TIEHI_1 DNA_8 DNA_9 DNA_10 DNA_11 DNA_12 DNA_13 DNA_14 DNA_15 DNB_8 DNB_9
+  DNB_10 DNB_11 DNB_12 DNB_13 DNB_14 DNB_15 FIOBTPA_40 FIOBTPB_42 GDLA_32
+  GDLA_33 GDLA_34 GDLA_35 GDLA_36 GDLA_37 GDLA_38 GDLA_39 GDLA_40 GDLA_41
+  GDLA_42 GDLA_43 GDLA_44 GDLA_45 GDLA_46 GDLA_47 GDLA_48 GDLA_49 GDLA_50
+  GDLA_51 GDLA_52 GDLA_53 GDLA_54 GDLA_55 GDLA_56 GDLA_57 GDLA_58 GDLA_59
+  GDLA_60 GDLA_61 GDLA_62 GDLA_63 GDLA__32 GDLA__33 GDLA__34 GDLA__35
+  GDLA__36 GDLA__37 GDLA__38 GDLA__39 GDLA__40 GDLA__41 GDLA__42 GDLA__43
+  GDLA__44 GDLA__45 GDLA__46 GDLA__47 GDLA__48 GDLA__49 GDLA__50 GDLA__51
+  GDLA__52 GDLA__53 GDLA__54 GDLA__55 GDLA__56 GDLA__57 GDLA__58 GDLA__59
+  GDLA__60 GDLA__61 GDLA__62 GDLA__63 GDLB_32 GDLB_33 GDLB_34 GDLB_35 GDLB_36
+  GDLB_37 GDLB_38 GDLB_39 GDLB_40 GDLB_41 GDLB_42 GDLB_43 GDLB_44 GDLB_45
+  GDLB_46 GDLB_47 GDLB_48 GDLB_49 GDLB_50 GDLB_51 GDLB_52 GDLB_53 GDLB_54
+  GDLB_55 GDLB_56 GDLB_57 GDLB_58 GDLB_59 GDLB_60 GDLB_61 GDLB_62 GDLB_63
+  GDLB__32 GDLB__33 GDLB__34 GDLB__35 GDLB__36 GDLB__37 GDLB__38 GDLB__39
+  GDLB__40 GDLB__41 GDLB__42 GDLB__43 GDLB__44 GDLB__45 GDLB__46 GDLB__47
+  GDLB__48 GDLB__49 GDLB__50 GDLB__51 GDLB__52 GDLB__53 GDLB__54 GDLB__55
+  GDLB__56 GDLB__57 GDLB__58 GDLB__59 GDLB__60 GDLB__61 GDLB__62 GDLB__63
+  IOBTPA_44 IOBTPB_46 IRET_1 ORET_1 QA__8 QA__9 QA__10 QA__11 QA__12 QA__13
+  QA__14 QA__15 QB__8 QB__9 QB__10 QB__11 QB__12 QB__13 QB__14 QB__15
+  STUB_BLA0_32 STUB_BLA0_33 STUB_BLA0_34 STUB_BLA0_35 STUB_BLA0_36
+  STUB_BLA0_37 STUB_BLA0_38 STUB_BLA0_39 STUB_BLA0_40 STUB_BLA0_41
+  STUB_BLA0_42 STUB_BLA0_43 STUB_BLA0_44 STUB_BLA0_45 STUB_BLA0_46
+  STUB_BLA0_47 STUB_BLA0_48 STUB_BLA0_49 STUB_BLA0_50 STUB_BLA0_51
+  STUB_BLA0_52 STUB_BLA0_53 STUB_BLA0_54 STUB_BLA0_55 STUB_BLA0_56
+  STUB_BLA0_57 STUB_BLA0_58 STUB_BLA0_59 STUB_BLA0_60 STUB_BLA0_61
+  STUB_BLA0_62 STUB_BLA0_63 STUB_BLA0__32 STUB_BLA0__33 STUB_BLA0__34
+  STUB_BLA0__35 STUB_BLA0__36 STUB_BLA0__37 STUB_BLA0__38 STUB_BLA0__39
+  STUB_BLA0__40 STUB_BLA0__41 STUB_BLA0__42 STUB_BLA0__43 STUB_BLA0__44
+  STUB_BLA0__45 STUB_BLA0__46 STUB_BLA0__47 STUB_BLA0__48 STUB_BLA0__49
+  STUB_BLA0__50 STUB_BLA0__51 STUB_BLA0__52 STUB_BLA0__53 STUB_BLA0__54
+  STUB_BLA0__55 STUB_BLA0__56 STUB_BLA0__57 STUB_BLA0__58 STUB_BLA0__59
+  STUB_BLA0__60 STUB_BLA0__61 STUB_BLA0__62 STUB_BLA0__63 STUB_BLA1_32
+  STUB_BLA1_33 STUB_BLA1_34 STUB_BLA1_35 STUB_BLA1_36 STUB_BLA1_37
+  STUB_BLA1_38 STUB_BLA1_39 STUB_BLA1_40 STUB_BLA1_41 STUB_BLA1_42
+  STUB_BLA1_43 STUB_BLA1_44 STUB_BLA1_45 STUB_BLA1_46 STUB_BLA1_47
+  STUB_BLA1_48 STUB_BLA1_49 STUB_BLA1_50 STUB_BLA1_51 STUB_BLA1_52
+  STUB_BLA1_53 STUB_BLA1_54 STUB_BLA1_55 STUB_BLA1_56 STUB_BLA1_57
+  STUB_BLA1_58 STUB_BLA1_59 STUB_BLA1_60 STUB_BLA1_61 STUB_BLA1_62
+  STUB_BLA1_63 STUB_BLA1__32 STUB_BLA1__33 STUB_BLA1__34 STUB_BLA1__35
+  STUB_BLA1__36 STUB_BLA1__37 STUB_BLA1__38 STUB_BLA1__39 STUB_BLA1__40
+  STUB_BLA1__41 STUB_BLA1__42 STUB_BLA1__43 STUB_BLA1__44 STUB_BLA1__45
+  STUB_BLA1__46 STUB_BLA1__47 STUB_BLA1__48 STUB_BLA1__49 STUB_BLA1__50
+  STUB_BLA1__51 STUB_BLA1__52 STUB_BLA1__53 STUB_BLA1__54 STUB_BLA1__55
+  STUB_BLA1__56 STUB_BLA1__57 STUB_BLA1__58 STUB_BLA1__59 STUB_BLA1__60
+  STUB_BLA1__61 STUB_BLA1__62 STUB_BLA1__63 STUB_BLA2_32 STUB_BLA2_33
+  STUB_BLA2_34 STUB_BLA2_35 STUB_BLA2_36 STUB_BLA2_37 STUB_BLA2_38
+  STUB_BLA2_39 STUB_BLA2_40 STUB_BLA2_41 STUB_BLA2_42 STUB_BLA2_43
+  STUB_BLA2_44 STUB_BLA2_45 STUB_BLA2_46 STUB_BLA2_47 STUB_BLA2_48
+  STUB_BLA2_49 STUB_BLA2_50 STUB_BLA2_51 STUB_BLA2_52 STUB_BLA2_53
+  STUB_BLA2_54 STUB_BLA2_55 STUB_BLA2_56 STUB_BLA2_57 STUB_BLA2_58
+  STUB_BLA2_59 STUB_BLA2_60 STUB_BLA2_61 STUB_BLA2_62 STUB_BLA2_63
+  STUB_BLA2__32 STUB_BLA2__33 STUB_BLA2__34 STUB_BLA2__35 STUB_BLA2__36
+  STUB_BLA2__37 STUB_BLA2__38 STUB_BLA2__39 STUB_BLA2__40 STUB_BLA2__41
+  STUB_BLA2__42 STUB_BLA2__43 STUB_BLA2__44 STUB_BLA2__45 STUB_BLA2__46
+  STUB_BLA2__47 STUB_BLA2__48 STUB_BLA2__49 STUB_BLA2__50 STUB_BLA2__51
+  STUB_BLA2__52 STUB_BLA2__53 STUB_BLA2__54 STUB_BLA2__55 STUB_BLA2__56
+  STUB_BLA2__57 STUB_BLA2__58 STUB_BLA2__59 STUB_BLA2__60 STUB_BLA2__61
+  STUB_BLA2__62 STUB_BLA2__63 STUB_BLA3_32 STUB_BLA3_33 STUB_BLA3_34
+  STUB_BLA3_35 STUB_BLA3_36 STUB_BLA3_37 STUB_BLA3_38 STUB_BLA3_39
+  STUB_BLA3_40 STUB_BLA3_41 STUB_BLA3_42 STUB_BLA3_43 STUB_BLA3_44
+  STUB_BLA3_45 STUB_BLA3_46 STUB_BLA3_47 STUB_BLA3_48 STUB_BLA3_49
+  STUB_BLA3_50 STUB_BLA3_51 STUB_BLA3_52 STUB_BLA3_53 STUB_BLA3_54
+  STUB_BLA3_55 STUB_BLA3_56 STUB_BLA3_57 STUB_BLA3_58 STUB_BLA3_59
+  STUB_BLA3_60 STUB_BLA3_61 STUB_BLA3_62 STUB_BLA3_63 STUB_BLA3__32
+  STUB_BLA3__33 STUB_BLA3__34 STUB_BLA3__35 STUB_BLA3__36 STUB_BLA3__37
+  STUB_BLA3__38 STUB_BLA3__39 STUB_BLA3__40 STUB_BLA3__41 STUB_BLA3__42
+  STUB_BLA3__43 STUB_BLA3__44 STUB_BLA3__45 STUB_BLA3__46 STUB_BLA3__47
+  STUB_BLA3__48 STUB_BLA3__49 STUB_BLA3__50 STUB_BLA3__51 STUB_BLA3__52
+  STUB_BLA3__53 STUB_BLA3__54 STUB_BLA3__55 STUB_BLA3__56 STUB_BLA3__57
+  STUB_BLA3__58 STUB_BLA3__59 STUB_BLA3__60 STUB_BLA3__61 STUB_BLA3__62
+  STUB_BLA3__63 STUB_BLB0_32 STUB_BLB0_33 STUB_BLB0_34 STUB_BLB0_35
+  STUB_BLB0_36 STUB_BLB0_37 STUB_BLB0_38 STUB_BLB0_39 STUB_BLB0_40
+  STUB_BLB0_41 STUB_BLB0_42 STUB_BLB0_43 STUB_BLB0_44 STUB_BLB0_45
+  STUB_BLB0_46 STUB_BLB0_47 STUB_BLB0_48 STUB_BLB0_49 STUB_BLB0_50
+  STUB_BLB0_51 STUB_BLB0_52 STUB_BLB0_53 STUB_BLB0_54 STUB_BLB0_55
+  STUB_BLB0_56 STUB_BLB0_57 STUB_BLB0_58 STUB_BLB0_59 STUB_BLB0_60
+  STUB_BLB0_61 STUB_BLB0_62 STUB_BLB0_63 STUB_BLB0__32 STUB_BLB0__33
+  STUB_BLB0__34 STUB_BLB0__35 STUB_BLB0__36 STUB_BLB0__37 STUB_BLB0__38
+  STUB_BLB0__39 STUB_BLB0__40 STUB_BLB0__41 STUB_BLB0__42 STUB_BLB0__43
+  STUB_BLB0__44 STUB_BLB0__45 STUB_BLB0__46 STUB_BLB0__47 STUB_BLB0__48
+  STUB_BLB0__49 STUB_BLB0__50 STUB_BLB0__51 STUB_BLB0__52 STUB_BLB0__53
+  STUB_BLB0__54 STUB_BLB0__55 STUB_BLB0__56 STUB_BLB0__57 STUB_BLB0__58
+  STUB_BLB0__59 STUB_BLB0__60 STUB_BLB0__61 STUB_BLB0__62 STUB_BLB0__63
+  STUB_BLB1_32 STUB_BLB1_33 STUB_BLB1_34 STUB_BLB1_35 STUB_BLB1_36
+  STUB_BLB1_37 STUB_BLB1_38 STUB_BLB1_39 STUB_BLB1_40 STUB_BLB1_41
+  STUB_BLB1_42 STUB_BLB1_43 STUB_BLB1_44 STUB_BLB1_45 STUB_BLB1_46
+  STUB_BLB1_47 STUB_BLB1_48 STUB_BLB1_49 STUB_BLB1_50 STUB_BLB1_51
+  STUB_BLB1_52 STUB_BLB1_53 STUB_BLB1_54 STUB_BLB1_55 STUB_BLB1_56
+  STUB_BLB1_57 STUB_BLB1_58 STUB_BLB1_59 STUB_BLB1_60 STUB_BLB1_61
+  STUB_BLB1_62 STUB_BLB1_63 STUB_BLB1__32 STUB_BLB1__33 STUB_BLB1__34
+  STUB_BLB1__35 STUB_BLB1__36 STUB_BLB1__37 STUB_BLB1__38 STUB_BLB1__39
+  STUB_BLB1__40 STUB_BLB1__41 STUB_BLB1__42 STUB_BLB1__43 STUB_BLB1__44
+  STUB_BLB1__45 STUB_BLB1__46 STUB_BLB1__47 STUB_BLB1__48 STUB_BLB1__49
+  STUB_BLB1__50 STUB_BLB1__51 STUB_BLB1__52 STUB_BLB1__53 STUB_BLB1__54
+  STUB_BLB1__55 STUB_BLB1__56 STUB_BLB1__57 STUB_BLB1__58 STUB_BLB1__59
+  STUB_BLB1__60 STUB_BLB1__61 STUB_BLB1__62 STUB_BLB1__63 STUB_BLB2_32
+  STUB_BLB2_33 STUB_BLB2_34 STUB_BLB2_35 STUB_BLB2_36 STUB_BLB2_37
+  STUB_BLB2_38 STUB_BLB2_39 STUB_BLB2_40 STUB_BLB2_41 STUB_BLB2_42
+  STUB_BLB2_43 STUB_BLB2_44 STUB_BLB2_45 STUB_BLB2_46 STUB_BLB2_47
+  STUB_BLB2_48 STUB_BLB2_49 STUB_BLB2_50 STUB_BLB2_51 STUB_BLB2_52
+  STUB_BLB2_53 STUB_BLB2_54 STUB_BLB2_55 STUB_BLB2_56 STUB_BLB2_57
+  STUB_BLB2_58 STUB_BLB2_59 STUB_BLB2_60 STUB_BLB2_61 STUB_BLB2_62
+  STUB_BLB2_63 STUB_BLB2__32 STUB_BLB2__33 STUB_BLB2__34 STUB_BLB2__35
+  STUB_BLB2__36 STUB_BLB2__37 STUB_BLB2__38 STUB_BLB2__39 STUB_BLB2__40
+  STUB_BLB2__41 STUB_BLB2__42 STUB_BLB2__43 STUB_BLB2__44 STUB_BLB2__45
+  STUB_BLB2__46 STUB_BLB2__47 STUB_BLB2__48 STUB_BLB2__49 STUB_BLB2__50
+  STUB_BLB2__51 STUB_BLB2__52 STUB_BLB2__53 STUB_BLB2__54 STUB_BLB2__55
+  STUB_BLB2__56 STUB_BLB2__57 STUB_BLB2__58 STUB_BLB2__59 STUB_BLB2__60
+  STUB_BLB2__61 STUB_BLB2__62 STUB_BLB2__63 STUB_BLB3_32 STUB_BLB3_33
+  STUB_BLB3_34 STUB_BLB3_35 STUB_BLB3_36 STUB_BLB3_37 STUB_BLB3_38
+  STUB_BLB3_39 STUB_BLB3_40 STUB_BLB3_41 STUB_BLB3_42 STUB_BLB3_43
+  STUB_BLB3_44 STUB_BLB3_45 STUB_BLB3_46 STUB_BLB3_47 STUB_BLB3_48
+  STUB_BLB3_49 STUB_BLB3_50 STUB_BLB3_51 STUB_BLB3_52 STUB_BLB3_53
+  STUB_BLB3_54 STUB_BLB3_55 STUB_BLB3_56 STUB_BLB3_57 STUB_BLB3_58
+  STUB_BLB3_59 STUB_BLB3_60 STUB_BLB3_61 STUB_BLB3_62 STUB_BLB3_63
+  STUB_BLB3__32 STUB_BLB3__33 STUB_BLB3__34 STUB_BLB3__35 STUB_BLB3__36
+  STUB_BLB3__37 STUB_BLB3__38 STUB_BLB3__39 STUB_BLB3__40 STUB_BLB3__41
+  STUB_BLB3__42 STUB_BLB3__43 STUB_BLB3__44 STUB_BLB3__45 STUB_BLB3__46
+  STUB_BLB3__47 STUB_BLB3__48 STUB_BLB3__49 STUB_BLB3__50 STUB_BLB3__51
+  STUB_BLB3__52 STUB_BLB3__53 STUB_BLB3__54 STUB_BLB3__55 STUB_BLB3__56
+  STUB_BLB3__57 STUB_BLB3__58 STUB_BLB3__59 STUB_BLB3__60 STUB_BLB3__61
+  STUB_BLB3__62 STUB_BLB3__63 TIELO_1 WEA_48 WEB_50 YP1_0_A_30 YP1_0_B_38
+  YP1_1_A_28 YP1_1_B_36 YP1_2_A_26 YP1_2_B_34 YP1_3_A_24 YP1_3_B_32 VDDPE
+  VDDCE VSSE pe_spad_1024x16_dpIO_ROW_R
.ENDS pe_spad_1024x16_dpGCTRL_ROW
****
.SUBCKT pe_spad_1024x16_dpSA2_HALF BTPSA BTPSA_A BTPSA_B BTPT BTPT_A BTPT_B
+  BTPWN BTPWN_A BTPWN_B DR DR_ DW DW_ GDL GDLT GDLT_ GDL_ SAEN SAEN_A SAEN_B
+  TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpSA2_HALF: 49 flat devices **
M0 TIELO_INTERNAL TIEHI_INTERNAL VSSE VSSE NCH_HVT W=0.27U L=0.06U M=1 $name=/N13/N00
M1 TIELO_INTERNAL TIELO_INTERNAL VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N3/N00
M10 VDDPE BTPSA NET195 VDDCE PCH W=0.72U L=0.06U M=1 $name=/tpgdlpret/P00
M11 NET195 SD_ SI_ VDDCE PCH W=0.45U L=0.06U M=1 $name=/tpgdlpre/P00
M12 DR_ BTPTRB SD_ VDDCE PCH W=1.2U L=0.06U M=1 $name=/tdracc/P00
M13 SD_ SAENB SD VDDCE PCH W=0.6U L=0.06U M=1 $name=/P9/P00
M14 VDDPE SAENB SD_ VDDCE PCH W=0.6U L=0.06U M=1 $name=/P8/P00
M15 NET195 SD SI VDDCE PCH W=0.45U L=0.06U M=1 $name=/P61/P00
M16 DR BTPTLB SD VDDCE PCH W=1.2U L=0.06U M=1 $name=/P24/P00
M17 SD_ SD VDDPE VDDCE PCH W=0.6U L=0.06U M=1 $name=/P13/P00
M18 VSSE TIELO SD VSSE NCH W=2U L=0.17U M=1 $name=/N0/N00
M19 VSSE TIELO SD_ VSSE NCH W=2U L=0.17U M=1 $name=/N2/N00
M2 VDDPE TIELO_INTERNAL TIEHI_INTERNAL VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/P2/P00
M20 SRC SD_ SD VSSE NCH W=4U L=0.17U M=1 $name=/tsdpd/N00
M21 VSSE SE SRC VSSE NCH W=4U L=0.17U M=1 $name=/tnpdsrc/N00
M22 SI_ SD_ VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tngdlpre/N00
M23 GDL_ SI_ VSSE VSSE NCH W=5U L=0.06U M=1 $name=/tngdldrv/N00
M24 SI SD VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N65/N00
M25 SRC SD SD_ VSSE NCH W=4U L=0.17U M=1 $name=/N5/N00
M26 SI BTPSA VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N23/N00
M27 SI_ BTPSA VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/N15/N00
M28 GDL SI VSSE VSSE NCH W=5U L=0.06U M=1 $name=/N14/N00
M29 SE BTPSA VSSE VSSE NCH W=0.21U L=0.06U M=1 $name=/gsaen/N10
M3 VDDPE TIEHI_INTERNAL TIEHI_INTERNAL VDDCE PCH_HVT W=0.15U L=0.06U M=1 $name=/P0/P00
M30 SE SAEN VSSE VSSE NCH W=0.21U L=0.06U M=1 $name=/gsaen/N00
M31 VDDPE BTPSA HNET132 VDDCE PCH W=1.01U L=0.06U M=1 $name=/gsaen/P01
M32 HNET132 SAEN SE VDDCE PCH W=1.01U L=0.06U M=1 $name=/gsaen/P00
M33 NET244 GDL_ VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/gdwnor/N10
M34 NET244 BTPWN VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/gdwnor/N00
M35 VDDPE GDL_ HNET136 VDDCE PCH W=1.64U L=0.06U M=1 $name=/gdwnor/P01
M36 HNET136 BTPWN NET244 VDDCE PCH W=1.64U L=0.06U M=1 $name=/gdwnor/P00
M37 NET259 GDL VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/I37/N10
M38 NET259 BTPWN VSSE VSSE NCH W=0.31U L=0.06U M=1 $name=/I37/N00
M39 VDDPE GDL HNET140 VDDCE PCH W=1.64U L=0.06U M=1 $name=/I37/P01
M4 TIELO TIEHI_INTERNAL VSSE VSSE NCH_HVT W=0.73U L=0.06U M=1 $name=/I17/N00
M40 HNET140 BTPWN NET259 VDDCE PCH W=1.64U L=0.06U M=1 $name=/I37/P00
M41 BTPTRB BTPT VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/ginva/N00
M42 VDDPE BTPT BTPTRB VDDCE PCH W=0.15U L=0.06U M=1 $name=/ginva/P00
M43 DW_ NET244 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/gdwt/N00
M44 VDDPE NET244 DW_ VDDCE PCH W=0.32U L=0.06U M=1 $name=/gdwt/P00
M45 DW NET259 VSSE VSSE NCH W=2.7U L=0.06U M=1 $name=/I40/N00
M46 VDDPE NET259 DW VDDCE PCH W=0.32U L=0.06U M=1 $name=/I40/P00
M47 BTPTLB BTPT VSSE VSSE NCH W=0.18U L=0.06U M=1 $name=/I27/N00
M48 VDDPE BTPT BTPTLB VDDCE PCH W=0.15U L=0.06U M=1 $name=/I27/P00
M5 VDDPE TIEHI_INTERNAL TIELO VDDCE PCH_HVT W=0.35U L=0.06U M=1 $name=/I17/P00
M6 SAENB SAEN VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/gsdpre/N00
M7 VDDPE SAEN SAENB VDDCE PCH_HVT W=0.22U L=0.06U M=1 $name=/gsdpre/P00
M8 SD SD_ VDDPE VDDCE PCH W=0.6U L=0.06U M=1 $name=/tsdpu/P00
M9 SD SAENB VDDPE VDDCE PCH W=0.6U L=0.06U M=1 $name=/tsdpre/P00
.ENDS pe_spad_1024x16_dpSA2_HALF
****
.SUBCKT pe_spad_1024x16_dpSAX1 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B
+  DR_0 DR_1 DR__0 DR__1 DW_0 DW_1 DW__0 DW__1 GDLT_0 GDLT_1 GDLT__0 GDLT__1
+  GDL_0 GDL_1 GDL__0 GDL__1 SAEN_A SAEN_B TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpSAX1: 98 flat devices **
XI0_0 BTPSA_A BTPSA_A BTPSA_B BTPT_A BTPT_A BTPT_B BTPWN_A BTPWN_A BTPWN_B
+  DR_0 DR__0 DW_0 DW__0 GDL_0 GDLT_0 GDLT__0 GDL__0 SAEN_A SAEN_A SAEN_B
+  TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpSA2_HALF
XI1_0 BTPSA_B BTPSA_A BTPSA_B BTPT_B BTPT_A BTPT_B BTPWN_B BTPWN_A BTPWN_B
+  DR_1 DR__1 DW_1 DW__1 GDL_1 GDLT_1 GDLT__1 GDL__1 SAEN_B SAEN_A SAEN_B
+  TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpSA2_HALF
.ENDS pe_spad_1024x16_dpSAX1
****
.SUBCKT pe_spad_1024x16_dpMUX_SA_HF BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B DR_0 DR_1 DR_2 DR_3 DR_4 DR_5 DR_6 DR_7 DR__0 DR__1 DR__2 DR__3
+  DR__4 DR__5 DR__6 DR__7 DW_0 DW_1 DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW__0 DW__1
+  DW__2 DW__3 DW__4 DW__5 DW__6 DW__7 GDLT_0 GDLT_1 GDLT_2 GDLT_3 GDLT_4
+  GDLT_5 GDLT_6 GDLT_7 GDLT__0 GDLT__1 GDLT__2 GDLT__3 GDLT__4 GDLT__5
+  GDLT__6 GDLT__7 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL__0
+  GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 SAEN_A SAEN_B TIELO VDDPE
+  VDDCE VSSE
** pe_spad_1024x16_dpMUX_SA_HF: 392 flat devices **
XI0_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B DR_0 DR_1 DR__0 DR__1 DW_0
+  DW_1 DW__0 DW__1 GDLT_0 GDLT_1 GDLT__0 GDLT__1 GDL_0 GDL_1 GDL__0 GDL__1
+  SAEN_A SAEN_B TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpSAX1
XI1_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B DR_3 DR_2 DR__3 DR__2 DW_3
+  DW_2 DW__3 DW__2 GDLT_3 GDLT_2 GDLT__3 GDLT__2 GDL_3 GDL_2 GDL__3 GDL__2
+  SAEN_A SAEN_B TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpSAX1
XI2_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B DR_4 DR_5 DR__4 DR__5 DW_4
+  DW_5 DW__4 DW__5 GDLT_4 GDLT_5 GDLT__4 GDLT__5 GDL_4 GDL_5 GDL__4 GDL__5
+  SAEN_A SAEN_B TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpSAX1
XI3_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B DR_7 DR_6 DR__7 DR__6 DW_7
+  DW_6 DW__7 DW__6 GDLT_7 GDLT_6 GDLT__7 GDLT__6 GDL_7 GDL_6 GDL__7 GDL__6
+  SAEN_A SAEN_B TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpSAX1
.ENDS pe_spad_1024x16_dpMUX_SA_HF
****
.SUBCKT pe_spad_1024x16_dpCD4 BL0_A BL0_B BL0__A BL0__B BL1_A BL1_B BL1__A
+  BL1__B BL2_A BL2_B BL2__A BL2__B BL3_A BL3_B BL3__A BL3__B BTP_A BTP_B
+  DRPREN_A DRPREN_B DR_A DR_B DR__A DR__B DW_A DW_B DW__A DW__B GDL0 GDL1
+  GDL2 GDL3 YP0AN YP0BN YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN
+  YP0_3_AN YP0_3_BN YP1AN YP1BN YP2AN YP2BN YP3AN YP3BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCD4: 104 flat devices **
M0 PRENA PREA VDDPE VDDCE PCH W=2.76U L=0.06U M=1 $name=/tppren/P00
M1 BL0_A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/tpchg/P00
M10 BL3_A PRENA BL3__A VDDCE PCH W=1.5U L=0.06U M=1 $name=/P78/P00
M100 YSEL0_B YP0BN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I61/N00
M101 VDDPE YP0BN YSEL0_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I61/P00
M102 YSELN0_B YSEL0_B VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I60/N00
M103 VDDPE YSEL0_B YSELN0_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I60/P00
M11 BL3_A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P77/P00
M12 BL3__A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P76/P00
M13 BL3_B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P75/P00
M14 BL3_B PRENB BL3__B VDDCE PCH W=1.5U L=0.06U M=1 $name=/P74/P00
M15 BL3__B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P72/P00
M16 BL2__B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P71/P00
M17 BL2__B PRENB BL2_B VDDCE PCH W=1.5U L=0.06U M=1 $name=/P70/P00
M18 BL2_B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P69/P00
M19 BL2__A PRENA BL2_A VDDCE PCH W=1.5U L=0.06U M=1 $name=/P68/P00
M2 BL0__A PRENA BL0_A VDDCE PCH W=1.5U L=0.06U M=1 $name=/teq/P00
M20 BL2__A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P67/P00
M21 BL2_A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P66/P00
M22 BL1_A PRENA BL1__A VDDCE PCH W=1.5U L=0.06U M=1 $name=/P65/P00
M23 BL1_A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P64/P00
M24 BL1__A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P63/P00
M25 BL1_B PRENB BL1__B VDDCE PCH W=1.5U L=0.06U M=1 $name=/P62/P00
M26 BL1_B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P61/P00
M27 BL1__B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P60/P00
M28 BL0__B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P59/P00
M29 BL0__B PRENB BL0_B VDDCE PCH W=1.5U L=0.06U M=1 $name=/P58/P00
M3 BL0_A YSELN0_A DR_A VDDCE PCH W=0.66U L=0.06U M=1 $name=/tblrd/P00
M30 BL0_B PRENB VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P57/P00
M31 PRENB PREB VDDPE VDDCE PCH W=2.76U L=0.06U M=1 $name=/P52/P00
M32 VDDPE DRPREN_B DR_B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P5/P00
M33 BL0__A YSELN0_A DR__A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P44/P00
M34 BL1__B YSELN1_B DR__B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P42/P00
M35 BL1_B YSELN1_B DR_B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P38/P00
M36 BL1_A YSELN1_A DR_A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P34/P00
M37 BL1__A YSELN1_A DR__A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P33/P00
M38 BL2__A YSELN2_A DR__A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P32/P00
M39 BL2_A YSELN2_A DR_A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P31/P00
M4 BL3_A YSELN3_A DR_A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P9/P00
M40 VDDPE DRPREN_B DR__B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P3/P00
M41 BL2_B YSELN2_B DR_B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P27/P00
M42 BL2__B YSELN2_B DR__B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P23/P00
M43 BL3__B YSELN3_B DR__B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P22/P00
M44 VDDPE DRPREN_A DR__A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P2/P00
M45 BL3_B YSELN3_B DR_B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P18/P00
M46 BL0_B YSELN0_B DR_B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P14/P00
M47 BL0__B YSELN0_B DR__B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P10/P00
M48 VDDPE DRPREN_A DR_A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P1/P00
M49 BL0__A PRENA VDDPE VDDCE PCH W=1.5U L=0.06U M=1 $name=/P0/P00
M5 VDDPE DW_B DR__B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P82/P00
M50 VSSE PREA PRENA VSSE NCH W=1.1U L=0.06U M=1 $name=/tnpren/N00
M51 BL0_A YSEL0_A DW_A VSSE NCH W=1U L=0.06U M=1 $name=/tblwr/N00
M52 BL0__A YSEL0_A DW__A VSSE NCH W=1U L=0.06U M=1 $name=/P4/N00
M53 VSSE PREB PRENB VSSE NCH W=1.1U L=0.06U M=1 $name=/N35/N00
M54 BL0_B YSEL0_B DW_B VSSE NCH W=1U L=0.06U M=1 $name=/N3/N00
M55 BL1__B YSEL1_B DW__B VSSE NCH W=1U L=0.06U M=1 $name=/N27/N00
M56 BL1_B YSEL1_B DW_B VSSE NCH W=1U L=0.06U M=1 $name=/N26/N00
M57 BL1_A YSEL1_A DW_A VSSE NCH W=1U L=0.06U M=1 $name=/N25/N00
M58 BL1__A YSEL1_A DW__A VSSE NCH W=1U L=0.06U M=1 $name=/N24/N00
M59 BL2__A YSEL2_A DW__A VSSE NCH W=1U L=0.06U M=1 $name=/N23/N00
M6 VDDPE DW__B DR_B VDDCE PCH W=0.66U L=0.06U M=1 $name=/P81/P00
M60 BL2_A YSEL2_A DW_A VSSE NCH W=1U L=0.06U M=1 $name=/N22/N00
M61 BL2_B YSEL2_B DW_B VSSE NCH W=1U L=0.06U M=1 $name=/N21/N00
M62 BL2__B YSEL2_B DW__B VSSE NCH W=1U L=0.06U M=1 $name=/N20/N00
M63 BL0__B YSEL0_B DW__B VSSE NCH W=1U L=0.06U M=1 $name=/N2/N00
M64 BL3__B YSEL3_B DW__B VSSE NCH W=1U L=0.06U M=1 $name=/N19/N00
M65 BL3_B YSEL3_B DW_B VSSE NCH W=1U L=0.06U M=1 $name=/N18/N00
M66 BL3_A YSEL3_A DW_A VSSE NCH W=1U L=0.06U M=1 $name=/N17/N00
M67 BL3__A YSEL3_A DW__A VSSE NCH W=1U L=0.06U M=1 $name=/N16/N00
M68 YSEL0_A YP0AN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/gysel2/N00
M69 VDDPE YP0AN YSEL0_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/gysel2/P00
M7 VDDPE DW_A DR__A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P80/P00
M70 YSELN0_A YSEL0_A VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/gysel1/N00
M71 VDDPE YSEL0_A YSELN0_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/gysel1/P00
M72 PREA BTP_A VSSE VSSE NCH W=0.72U L=0.06U M=1 $name=/gpre/N00
M73 VDDPE BTP_A PREA VDDCE PCH W=0.6U L=0.06U M=1 $name=/gpre/P00
M74 PREB BTP_B VSSE VSSE NCH W=0.72U L=0.06U M=1 $name=/I78/N00
M75 VDDPE BTP_B PREB VDDCE PCH W=0.6U L=0.06U M=1 $name=/I78/P00
M76 YSEL3_A YP3AN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I73/N00
M77 VDDPE YP3AN YSEL3_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/I73/P00
M78 YSELN3_A YSEL3_A VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I72/N00
M79 VDDPE YSEL3_A YSELN3_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/I72/P00
M8 BL3__A YSELN3_A DR__A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P8/P00
M80 YSELN3_B YSEL3_B VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I71/N00
M81 VDDPE YSEL3_B YSELN3_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I71/P00
M82 YSEL3_B YP3BN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I70/N00
M83 VDDPE YP3BN YSEL3_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I70/P00
M84 YSELN2_B YSEL2_B VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I69/N00
M85 VDDPE YSEL2_B YSELN2_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I69/P00
M86 YSEL2_B YP2BN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I68/N00
M87 VDDPE YP2BN YSEL2_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I68/P00
M88 YSEL2_A YP2AN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I67/N00
M89 VDDPE YP2AN YSEL2_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/I67/P00
M9 VDDPE DW__A DR_A VDDCE PCH W=0.66U L=0.06U M=1 $name=/P79/P00
M90 YSELN2_A YSEL2_A VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I66/N00
M91 VDDPE YSEL2_A YSELN2_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/I66/P00
M92 YSEL1_A YP1AN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I65/N00
M93 VDDPE YP1AN YSEL1_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/I65/P00
M94 YSELN1_A YSEL1_A VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I64/N00
M95 VDDPE YSEL1_A YSELN1_A VDDCE PCH W=0.44U L=0.06U M=1 $name=/I64/P00
M96 YSELN1_B YSEL1_B VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I63/N00
M97 VDDPE YSEL1_B YSELN1_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I63/P00
M98 YSEL1_B YP1BN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/I62/N00
M99 VDDPE YP1BN YSEL1_B VDDCE PCH W=0.44U L=0.06U M=1 $name=/I62/P00
.ENDS pe_spad_1024x16_dpCD4
****
.SUBCKT pe_spad_1024x16_dpCDLX BL0_A BL0_B BL0__A BL0__B BL1_A BL1_B BL1__A
+  BL1__B BL2_A BL2_B BL2__A BL2__B BL3_A BL3_B BL3__A BL3__B BTP_A BTP_B
+  DRPREN_A DRPREN_B DR_A DR_B DR__A DR__B DW_A DW_B DW__A DW__B GDL0 GDL1
+  GDL2 GDL3 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN
+  YP0_3_BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCDLX: 104 flat devices **
XI0_0 BL0_A BL0_B BL0__A BL0__B BL1_A BL1_B BL1__A BL1__B BL2_A BL2_B BL2__A
+  BL2__B BL3_A BL3_B BL3__A BL3__B BTP_A BTP_B DRPREN_A DRPREN_B DR_A DR_B
+  DR__A DR__B DW_A DW_B DW__A DW__B GDL0 GDL1 GDL2 GDL3 YP0_0_AN YP0_0_BN
+  YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCD4
.ENDS pe_spad_1024x16_dpCDLX
****
.SUBCKT pe_spad_1024x16_dpCDRX BL0_A BL0_B BL0__A BL0__B BL1_A BL1_B BL1__A
+  BL1__B BL2_A BL2_B BL2__A BL2__B BL3_A BL3_B BL3__A BL3__B BTP_A BTP_B
+  DRPREN_A DRPREN_B DR_A DR_B DR__A DR__B DW_A DW_B DW__A DW__B GDL0 GDL1
+  GDL2 GDL3 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN
+  YP0_3_BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCDRX: 104 flat devices **
XI0_0 BL0_A BL0_B BL0__A BL0__B BL1_A BL1_B BL1__A BL1__B BL2_A BL2_B BL2__A
+  BL2__B BL3_A BL3_B BL3__A BL3__B BTP_A BTP_B DRPREN_A DRPREN_B DR_A DR_B
+  DR__A DR__B DW_A DW_B DW__A DW__B GDL0 GDL1 GDL2 GDL3 YP0_0_AN YP0_0_BN
+  YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCD4
.ENDS pe_spad_1024x16_dpCDRX
****
.SUBCKT pe_spad_1024x16_dpMUX_CD BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3 BL0_B_0
+  BL0_B_1 BL0_B_2 BL0_B_3 BL0__A_0 BL0__A_1 BL0__A_2 BL0__A_3 BL0__B_0
+  BL0__B_1 BL0__B_2 BL0__B_3 BL1_A_0 BL1_A_1 BL1_A_2 BL1_A_3 BL1_B_0 BL1_B_1
+  BL1_B_2 BL1_B_3 BL1__A_0 BL1__A_1 BL1__A_2 BL1__A_3 BL1__B_0 BL1__B_1
+  BL1__B_2 BL1__B_3 BL2_A_0 BL2_A_1 BL2_A_2 BL2_A_3 BL2_B_0 BL2_B_1 BL2_B_2
+  BL2_B_3 BL2__A_0 BL2__A_1 BL2__A_2 BL2__A_3 BL2__B_0 BL2__B_1 BL2__B_2
+  BL2__B_3 BL3_A_0 BL3_A_1 BL3_A_2 BL3_A_3 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3
+  BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3 BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3
+  BTP_A BTP_B DRPREN_A DRPREN_B DR_A_0 DR_A_1 DR_A_2 DR_A_3 DR_B_0 DR_B_1
+  DR_B_2 DR_B_3 DR__A_0 DR__A_1 DR__A_2 DR__A_3 DR__B_0 DR__B_1 DR__B_2
+  DR__B_3 DW_A_0 DW_A_1 DW_A_2 DW_A_3 DW_B_0 DW_B_1 DW_B_2 DW_B_3 DW__A_0
+  DW__A_1 DW__A_2 DW__A_3 DW__B_0 DW__B_1 DW__B_2 DW__B_3 GDL0_0 GDL0_1
+  GDL0_2 GDL0_3 GDL1_0 GDL1_1 GDL1_2 GDL1_3 GDL2_0 GDL2_1 GDL2_2 GDL2_3
+  GDL3_0 GDL3_1 GDL3_2 GDL3_3 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMUX_CD: 416 flat devices **
XI0_0 BL0_A_0 BL0_B_0 BL0__A_0 BL0__B_0 BL1_A_0 BL1_B_0 BL1__A_0 BL1__B_0
+  BL2_A_0 BL2_B_0 BL2__A_0 BL2__B_0 BL3_A_0 BL3_B_0 BL3__A_0 BL3__B_0 BTP_A
+  BTP_B DRPREN_A DRPREN_B DR_A_0 DR_B_0 DR__A_0 DR__B_0 DW_A_0 DW_B_0 DW__A_0
+  DW__B_0 GDL0_0 GDL1_0 GDL2_0 GDL3_0 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN
+  YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpCDLX
XI1_0 BL0_A_1 BL0_B_1 BL0__A_1 BL0__B_1 BL1_A_1 BL1_B_1 BL1__A_1 BL1__B_1
+  BL2_A_1 BL2_B_1 BL2__A_1 BL2__B_1 BL3_A_1 BL3_B_1 BL3__A_1 BL3__B_1 BTP_A
+  BTP_B DRPREN_A DRPREN_B DR_A_1 DR_B_1 DR__A_1 DR__B_1 DW_A_1 DW_B_1 DW__A_1
+  DW__B_1 GDL0_1 GDL1_1 GDL2_1 GDL3_1 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN
+  YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpCDRX
XI2_0 BL0_A_2 BL0_B_2 BL0__A_2 BL0__B_2 BL1_A_2 BL1_B_2 BL1__A_2 BL1__B_2
+  BL2_A_2 BL2_B_2 BL2__A_2 BL2__B_2 BL3_A_2 BL3_B_2 BL3__A_2 BL3__B_2 BTP_A
+  BTP_B DRPREN_A DRPREN_B DR_A_2 DR_B_2 DR__A_2 DR__B_2 DW_A_2 DW_B_2 DW__A_2
+  DW__B_2 GDL0_2 GDL1_2 GDL2_2 GDL3_2 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN
+  YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpCDLX
XI3_0 BL0_A_3 BL0_B_3 BL0__A_3 BL0__B_3 BL1_A_3 BL1_B_3 BL1__A_3 BL1__B_3
+  BL2_A_3 BL2_B_3 BL2__A_3 BL2__B_3 BL3_A_3 BL3_B_3 BL3__A_3 BL3__B_3 BTP_A
+  BTP_B DRPREN_A DRPREN_B DR_A_3 DR_B_3 DR__A_3 DR__B_3 DW_A_3 DW_B_3 DW__A_3
+  DW__B_3 GDL0_3 GDL1_3 GDL2_3 GDL3_3 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN
+  YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpCDRX
.ENDS pe_spad_1024x16_dpMUX_CD
****
.SUBCKT pe_spad_1024x16_dpMUX_COL_HF BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3 BL0_B_0
+  BL0_B_1 BL0_B_2 BL0_B_3 BL0__A_0 BL0__A_1 BL0__A_2 BL0__A_3 BL0__B_0
+  BL0__B_1 BL0__B_2 BL0__B_3 BL1_A_0 BL1_A_1 BL1_A_2 BL1_A_3 BL1_B_0 BL1_B_1
+  BL1_B_2 BL1_B_3 BL1__A_0 BL1__A_1 BL1__A_2 BL1__A_3 BL1__B_0 BL1__B_1
+  BL1__B_2 BL1__B_3 BL2_A_0 BL2_A_1 BL2_A_2 BL2_A_3 BL2_B_0 BL2_B_1 BL2_B_2
+  BL2_B_3 BL2__A_0 BL2__A_1 BL2__A_2 BL2__A_3 BL2__B_0 BL2__B_1 BL2__B_2
+  BL2__B_3 BL3_A_0 BL3_A_1 BL3_A_2 BL3_A_3 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3
+  BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3 BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3
+  BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B
+  GDL0_0 GDL0_1 GDL0_2 GDL0_3 GDL1_0 GDL1_1 GDL1_2 GDL1_3 GDL2_0 GDL2_1
+  GDL2_2 GDL2_3 GDL3_0 GDL3_1 GDL3_2 GDL3_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7
+  SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN
+  YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMUX_COL_HF: 808 flat devices **
XI0_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B DR_0 DR_1 DR_2 DR_3 DR_4
+  DR_5 DR_6 DR_7 DR__0 DR__1 DR__2 DR__3 DR__4 DR__5 DR__6 DR__7 DW_0 DW_1
+  DW_2 DW_3 DW_4 DW_5 DW_6 DW_7 DW__0 DW__1 DW__2 DW__3 DW__4 DW__5 DW__6
+  DW__7 GDL0_0 GDL3_0 GDL3_1 GDL0_1 GDL0_2 GDL3_2 GDL3_3 GDL0_3 GDL1_0 GDL2_0
+  GDL2_1 GDL1_1 GDL1_2 GDL2_2 GDL2_3 GDL1_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7
+  SAEN_A SAEN_B TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_SA_HF
XI0_1 BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3 BL0_B_0 BL0_B_1 BL0_B_2 BL0_B_3 BL0__A_0
+  BL0__A_1 BL0__A_2 BL0__A_3 BL0__B_0 BL0__B_1 BL0__B_2 BL0__B_3 BL1_A_0
+  BL1_A_1 BL1_A_2 BL1_A_3 BL1_B_0 BL1_B_1 BL1_B_2 BL1_B_3 BL1__A_0 BL1__A_1
+  BL1__A_2 BL1__A_3 BL1__B_0 BL1__B_1 BL1__B_2 BL1__B_3 BL2_A_0 BL2_A_1
+  BL2_A_2 BL2_A_3 BL2_B_0 BL2_B_1 BL2_B_2 BL2_B_3 BL2__A_0 BL2__A_1 BL2__A_2
+  BL2__A_3 BL2__B_0 BL2__B_1 BL2__B_2 BL2__B_3 BL3_A_0 BL3_A_1 BL3_A_2
+  BL3_A_3 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3 BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3
+  BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3 BTP_A BTP_B DRPREN_A DRPREN_B DR_0 DR_3
+  DR_4 DR_7 DR_1 DR_2 DR_5 DR_6 DR__0 DR__3 DR__4 DR__7 DR__1 DR__2 DR__5
+  DR__6 DW_0 DW_3 DW_4 DW_7 DW_1 DW_2 DW_5 DW_6 DW__0 DW__3 DW__4 DW__7 DW__1
+  DW__2 DW__5 DW__6 GDL0_0 GDL0_1 GDL0_2 GDL0_3 GDL1_0 GDL1_1 GDL1_2 GDL1_3
+  GDL2_0 GDL2_1 GDL2_2 GDL2_3 GDL3_0 GDL3_1 GDL3_2 GDL3_3 YP0_0_AN YP0_0_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMUX_CD
.ENDS pe_spad_1024x16_dpMUX_COL_HF
****
.SUBCKT pe_spad_1024x16_dpFCSA2_HALF BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B SAEN_A SAEN_B TIELO VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFCSA2_HALF: 1 flat devices **
M0 TIELO TIELO TIELO VSSE NCH W=2.4U L=0.17U M=1 $name=/N2/N00
.ENDS pe_spad_1024x16_dpFCSA2_HALF
****
.SUBCKT pe_spad_1024x16_dpCD_EDGE_HF BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCD_EDGE_HF: 1 flat devices **
XI0_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B SAEN_A SAEN_B TIELO VDDPE
+  VDDCE VSSE pe_spad_1024x16_dpFCSA2_HALF
.ENDS pe_spad_1024x16_dpCD_EDGE_HF
****
.SUBCKT pe_spad_1024x16_dpMUXCOL_ROW_HF_L BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3
+  BL0_A_4 BL0_A_5 BL0_A_6 BL0_A_7 BL0_A_8 BL0_A_9 BL0_A_10 BL0_A_11 BL0_A_12
+  BL0_A_13 BL0_A_14 BL0_A_15 BL0_A_16 BL0_A_17 BL0_A_18 BL0_A_19 BL0_A_20
+  BL0_A_21 BL0_A_22 BL0_A_23 BL0_A_24 BL0_A_25 BL0_A_26 BL0_A_27 BL0_A_28
+  BL0_A_29 BL0_A_30 BL0_A_31 BL0_B_0 BL0_B_1 BL0_B_2 BL0_B_3 BL0_B_4 BL0_B_5
+  BL0_B_6 BL0_B_7 BL0_B_8 BL0_B_9 BL0_B_10 BL0_B_11 BL0_B_12 BL0_B_13
+  BL0_B_14 BL0_B_15 BL0_B_16 BL0_B_17 BL0_B_18 BL0_B_19 BL0_B_20 BL0_B_21
+  BL0_B_22 BL0_B_23 BL0_B_24 BL0_B_25 BL0_B_26 BL0_B_27 BL0_B_28 BL0_B_29
+  BL0_B_30 BL0_B_31 BL0__A_0 BL0__A_1 BL0__A_2 BL0__A_3 BL0__A_4 BL0__A_5
+  BL0__A_6 BL0__A_7 BL0__A_8 BL0__A_9 BL0__A_10 BL0__A_11 BL0__A_12 BL0__A_13
+  BL0__A_14 BL0__A_15 BL0__A_16 BL0__A_17 BL0__A_18 BL0__A_19 BL0__A_20
+  BL0__A_21 BL0__A_22 BL0__A_23 BL0__A_24 BL0__A_25 BL0__A_26 BL0__A_27
+  BL0__A_28 BL0__A_29 BL0__A_30 BL0__A_31 BL0__B_0 BL0__B_1 BL0__B_2 BL0__B_3
+  BL0__B_4 BL0__B_5 BL0__B_6 BL0__B_7 BL0__B_8 BL0__B_9 BL0__B_10 BL0__B_11
+  BL0__B_12 BL0__B_13 BL0__B_14 BL0__B_15 BL0__B_16 BL0__B_17 BL0__B_18
+  BL0__B_19 BL0__B_20 BL0__B_21 BL0__B_22 BL0__B_23 BL0__B_24 BL0__B_25
+  BL0__B_26 BL0__B_27 BL0__B_28 BL0__B_29 BL0__B_30 BL0__B_31 BL1_A_0 BL1_A_1
+  BL1_A_2 BL1_A_3 BL1_A_4 BL1_A_5 BL1_A_6 BL1_A_7 BL1_A_8 BL1_A_9 BL1_A_10
+  BL1_A_11 BL1_A_12 BL1_A_13 BL1_A_14 BL1_A_15 BL1_A_16 BL1_A_17 BL1_A_18
+  BL1_A_19 BL1_A_20 BL1_A_21 BL1_A_22 BL1_A_23 BL1_A_24 BL1_A_25 BL1_A_26
+  BL1_A_27 BL1_A_28 BL1_A_29 BL1_A_30 BL1_A_31 BL1_B_0 BL1_B_1 BL1_B_2
+  BL1_B_3 BL1_B_4 BL1_B_5 BL1_B_6 BL1_B_7 BL1_B_8 BL1_B_9 BL1_B_10 BL1_B_11
+  BL1_B_12 BL1_B_13 BL1_B_14 BL1_B_15 BL1_B_16 BL1_B_17 BL1_B_18 BL1_B_19
+  BL1_B_20 BL1_B_21 BL1_B_22 BL1_B_23 BL1_B_24 BL1_B_25 BL1_B_26 BL1_B_27
+  BL1_B_28 BL1_B_29 BL1_B_30 BL1_B_31 BL1__A_0 BL1__A_1 BL1__A_2 BL1__A_3
+  BL1__A_4 BL1__A_5 BL1__A_6 BL1__A_7 BL1__A_8 BL1__A_9 BL1__A_10 BL1__A_11
+  BL1__A_12 BL1__A_13 BL1__A_14 BL1__A_15 BL1__A_16 BL1__A_17 BL1__A_18
+  BL1__A_19 BL1__A_20 BL1__A_21 BL1__A_22 BL1__A_23 BL1__A_24 BL1__A_25
+  BL1__A_26 BL1__A_27 BL1__A_28 BL1__A_29 BL1__A_30 BL1__A_31 BL1__B_0
+  BL1__B_1 BL1__B_2 BL1__B_3 BL1__B_4 BL1__B_5 BL1__B_6 BL1__B_7 BL1__B_8
+  BL1__B_9 BL1__B_10 BL1__B_11 BL1__B_12 BL1__B_13 BL1__B_14 BL1__B_15
+  BL1__B_16 BL1__B_17 BL1__B_18 BL1__B_19 BL1__B_20 BL1__B_21 BL1__B_22
+  BL1__B_23 BL1__B_24 BL1__B_25 BL1__B_26 BL1__B_27 BL1__B_28 BL1__B_29
+  BL1__B_30 BL1__B_31 BL2_A_0 BL2_A_1 BL2_A_2 BL2_A_3 BL2_A_4 BL2_A_5 BL2_A_6
+  BL2_A_7 BL2_A_8 BL2_A_9 BL2_A_10 BL2_A_11 BL2_A_12 BL2_A_13 BL2_A_14
+  BL2_A_15 BL2_A_16 BL2_A_17 BL2_A_18 BL2_A_19 BL2_A_20 BL2_A_21 BL2_A_22
+  BL2_A_23 BL2_A_24 BL2_A_25 BL2_A_26 BL2_A_27 BL2_A_28 BL2_A_29 BL2_A_30
+  BL2_A_31 BL2_B_0 BL2_B_1 BL2_B_2 BL2_B_3 BL2_B_4 BL2_B_5 BL2_B_6 BL2_B_7
+  BL2_B_8 BL2_B_9 BL2_B_10 BL2_B_11 BL2_B_12 BL2_B_13 BL2_B_14 BL2_B_15
+  BL2_B_16 BL2_B_17 BL2_B_18 BL2_B_19 BL2_B_20 BL2_B_21 BL2_B_22 BL2_B_23
+  BL2_B_24 BL2_B_25 BL2_B_26 BL2_B_27 BL2_B_28 BL2_B_29 BL2_B_30 BL2_B_31
+  BL2__A_0 BL2__A_1 BL2__A_2 BL2__A_3 BL2__A_4 BL2__A_5 BL2__A_6 BL2__A_7
+  BL2__A_8 BL2__A_9 BL2__A_10 BL2__A_11 BL2__A_12 BL2__A_13 BL2__A_14
+  BL2__A_15 BL2__A_16 BL2__A_17 BL2__A_18 BL2__A_19 BL2__A_20 BL2__A_21
+  BL2__A_22 BL2__A_23 BL2__A_24 BL2__A_25 BL2__A_26 BL2__A_27 BL2__A_28
+  BL2__A_29 BL2__A_30 BL2__A_31 BL2__B_0 BL2__B_1 BL2__B_2 BL2__B_3 BL2__B_4
+  BL2__B_5 BL2__B_6 BL2__B_7 BL2__B_8 BL2__B_9 BL2__B_10 BL2__B_11 BL2__B_12
+  BL2__B_13 BL2__B_14 BL2__B_15 BL2__B_16 BL2__B_17 BL2__B_18 BL2__B_19
+  BL2__B_20 BL2__B_21 BL2__B_22 BL2__B_23 BL2__B_24 BL2__B_25 BL2__B_26
+  BL2__B_27 BL2__B_28 BL2__B_29 BL2__B_30 BL2__B_31 BL3_A_0 BL3_A_1 BL3_A_2
+  BL3_A_3 BL3_A_4 BL3_A_5 BL3_A_6 BL3_A_7 BL3_A_8 BL3_A_9 BL3_A_10 BL3_A_11
+  BL3_A_12 BL3_A_13 BL3_A_14 BL3_A_15 BL3_A_16 BL3_A_17 BL3_A_18 BL3_A_19
+  BL3_A_20 BL3_A_21 BL3_A_22 BL3_A_23 BL3_A_24 BL3_A_25 BL3_A_26 BL3_A_27
+  BL3_A_28 BL3_A_29 BL3_A_30 BL3_A_31 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3 BL3_B_4
+  BL3_B_5 BL3_B_6 BL3_B_7 BL3_B_8 BL3_B_9 BL3_B_10 BL3_B_11 BL3_B_12 BL3_B_13
+  BL3_B_14 BL3_B_15 BL3_B_16 BL3_B_17 BL3_B_18 BL3_B_19 BL3_B_20 BL3_B_21
+  BL3_B_22 BL3_B_23 BL3_B_24 BL3_B_25 BL3_B_26 BL3_B_27 BL3_B_28 BL3_B_29
+  BL3_B_30 BL3_B_31 BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3 BL3__A_4 BL3__A_5
+  BL3__A_6 BL3__A_7 BL3__A_8 BL3__A_9 BL3__A_10 BL3__A_11 BL3__A_12 BL3__A_13
+  BL3__A_14 BL3__A_15 BL3__A_16 BL3__A_17 BL3__A_18 BL3__A_19 BL3__A_20
+  BL3__A_21 BL3__A_22 BL3__A_23 BL3__A_24 BL3__A_25 BL3__A_26 BL3__A_27
+  BL3__A_28 BL3__A_29 BL3__A_30 BL3__A_31 BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3
+  BL3__B_4 BL3__B_5 BL3__B_6 BL3__B_7 BL3__B_8 BL3__B_9 BL3__B_10 BL3__B_11
+  BL3__B_12 BL3__B_13 BL3__B_14 BL3__B_15 BL3__B_16 BL3__B_17 BL3__B_18
+  BL3__B_19 BL3__B_20 BL3__B_21 BL3__B_22 BL3__B_23 BL3__B_24 BL3__B_25
+  BL3__B_26 BL3__B_27 BL3__B_28 BL3__B_29 BL3__B_30 BL3__B_31 BTPSA_A BTPSA_B
+  BTPT_A BTPT_B BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_0 GDL0_1
+  GDL0_2 GDL0_3 GDL0_4 GDL0_5 GDL0_6 GDL0_7 GDL0_8 GDL0_9 GDL0_10 GDL0_11
+  GDL0_12 GDL0_13 GDL0_14 GDL0_15 GDL0_16 GDL0_17 GDL0_18 GDL0_19 GDL0_20
+  GDL0_21 GDL0_22 GDL0_23 GDL0_24 GDL0_25 GDL0_26 GDL0_27 GDL0_28 GDL0_29
+  GDL0_30 GDL0_31 GDL1_0 GDL1_1 GDL1_2 GDL1_3 GDL1_4 GDL1_5 GDL1_6 GDL1_7
+  GDL1_8 GDL1_9 GDL1_10 GDL1_11 GDL1_12 GDL1_13 GDL1_14 GDL1_15 GDL1_16
+  GDL1_17 GDL1_18 GDL1_19 GDL1_20 GDL1_21 GDL1_22 GDL1_23 GDL1_24 GDL1_25
+  GDL1_26 GDL1_27 GDL1_28 GDL1_29 GDL1_30 GDL1_31 GDL2_0 GDL2_1 GDL2_2 GDL2_3
+  GDL2_4 GDL2_5 GDL2_6 GDL2_7 GDL2_8 GDL2_9 GDL2_10 GDL2_11 GDL2_12 GDL2_13
+  GDL2_14 GDL2_15 GDL2_16 GDL2_17 GDL2_18 GDL2_19 GDL2_20 GDL2_21 GDL2_22
+  GDL2_23 GDL2_24 GDL2_25 GDL2_26 GDL2_27 GDL2_28 GDL2_29 GDL2_30 GDL2_31
+  GDL3_0 GDL3_1 GDL3_2 GDL3_3 GDL3_4 GDL3_5 GDL3_6 GDL3_7 GDL3_8 GDL3_9
+  GDL3_10 GDL3_11 GDL3_12 GDL3_13 GDL3_14 GDL3_15 GDL3_16 GDL3_17 GDL3_18
+  GDL3_19 GDL3_20 GDL3_21 GDL3_22 GDL3_23 GDL3_24 GDL3_25 GDL3_26 GDL3_27
+  GDL3_28 GDL3_29 GDL3_30 GDL3_31 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6
+  GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17
+  GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27
+  GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37
+  GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47
+  GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57
+  GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL__0 GDL__1 GDL__2 GDL__3
+  GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13
+  GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21 GDL__22
+  GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30 GDL__31
+  GDL__32 GDL__33 GDL__34 GDL__35 GDL__36 GDL__37 GDL__38 GDL__39 GDL__40
+  GDL__41 GDL__42 GDL__43 GDL__44 GDL__45 GDL__46 GDL__47 GDL__48 GDL__49
+  GDL__50 GDL__51 GDL__52 GDL__53 GDL__54 GDL__55 GDL__56 GDL__57 GDL__58
+  GDL__59 GDL__60 GDL__61 GDL__62 GDL__63 SAEN_A SAEN_B TIELO YP0_0_AN
+  YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE
+  VSSE
** pe_spad_1024x16_dpMUXCOL_ROW_HF_L: 6465 flat devices **
XI0_0 BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3 BL0_B_0 BL0_B_1 BL0_B_2 BL0_B_3 BL0__A_0
+  BL0__A_1 BL0__A_2 BL0__A_3 BL0__B_0 BL0__B_1 BL0__B_2 BL0__B_3 BL1_A_0
+  BL1_A_1 BL1_A_2 BL1_A_3 BL1_B_0 BL1_B_1 BL1_B_2 BL1_B_3 BL1__A_0 BL1__A_1
+  BL1__A_2 BL1__A_3 BL1__B_0 BL1__B_1 BL1__B_2 BL1__B_3 BL2_A_0 BL2_A_1
+  BL2_A_2 BL2_A_3 BL2_B_0 BL2_B_1 BL2_B_2 BL2_B_3 BL2__A_0 BL2__A_1 BL2__A_2
+  BL2__A_3 BL2__B_0 BL2__B_1 BL2__B_2 BL2__B_3 BL3_A_0 BL3_A_1 BL3_A_2
+  BL3_A_3 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3 BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3
+  BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_0 GDL0_1 GDL0_2 GDL0_3 GDL1_0
+  GDL1_1 GDL1_2 GDL1_3 GDL2_0 GDL2_1 GDL2_2 GDL2_3 GDL3_0 GDL3_1 GDL3_2
+  GDL3_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL__0 GDL__1 GDL__2
+  GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMUX_COL_HF
XI1_0 BL0_A_4 BL0_A_5 BL0_A_6 BL0_A_7 BL0_B_4 BL0_B_5 BL0_B_6 BL0_B_7 BL0__A_4
+  BL0__A_5 BL0__A_6 BL0__A_7 BL0__B_4 BL0__B_5 BL0__B_6 BL0__B_7 BL1_A_4
+  BL1_A_5 BL1_A_6 BL1_A_7 BL1_B_4 BL1_B_5 BL1_B_6 BL1_B_7 BL1__A_4 BL1__A_5
+  BL1__A_6 BL1__A_7 BL1__B_4 BL1__B_5 BL1__B_6 BL1__B_7 BL2_A_4 BL2_A_5
+  BL2_A_6 BL2_A_7 BL2_B_4 BL2_B_5 BL2_B_6 BL2_B_7 BL2__A_4 BL2__A_5 BL2__A_6
+  BL2__A_7 BL2__B_4 BL2__B_5 BL2__B_6 BL2__B_7 BL3_A_4 BL3_A_5 BL3_A_6
+  BL3_A_7 BL3_B_4 BL3_B_5 BL3_B_6 BL3_B_7 BL3__A_4 BL3__A_5 BL3__A_6 BL3__A_7
+  BL3__B_4 BL3__B_5 BL3__B_6 BL3__B_7 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_4 GDL0_5 GDL0_6 GDL0_7 GDL1_4
+  GDL1_5 GDL1_6 GDL1_7 GDL2_4 GDL2_5 GDL2_6 GDL2_7 GDL3_4 GDL3_5 GDL3_6
+  GDL3_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 SAEN_A SAEN_B TIELO
+  YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI2_0 BL0_A_8 BL0_A_9 BL0_A_10 BL0_A_11 BL0_B_8 BL0_B_9 BL0_B_10 BL0_B_11
+  BL0__A_8 BL0__A_9 BL0__A_10 BL0__A_11 BL0__B_8 BL0__B_9 BL0__B_10 BL0__B_11
+  BL1_A_8 BL1_A_9 BL1_A_10 BL1_A_11 BL1_B_8 BL1_B_9 BL1_B_10 BL1_B_11
+  BL1__A_8 BL1__A_9 BL1__A_10 BL1__A_11 BL1__B_8 BL1__B_9 BL1__B_10 BL1__B_11
+  BL2_A_8 BL2_A_9 BL2_A_10 BL2_A_11 BL2_B_8 BL2_B_9 BL2_B_10 BL2_B_11
+  BL2__A_8 BL2__A_9 BL2__A_10 BL2__A_11 BL2__B_8 BL2__B_9 BL2__B_10 BL2__B_11
+  BL3_A_8 BL3_A_9 BL3_A_10 BL3_A_11 BL3_B_8 BL3_B_9 BL3_B_10 BL3_B_11
+  BL3__A_8 BL3__A_9 BL3__A_10 BL3__A_11 BL3__B_8 BL3__B_9 BL3__B_10 BL3__B_11
+  BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B
+  GDL0_8 GDL0_9 GDL0_10 GDL0_11 GDL1_8 GDL1_9 GDL1_10 GDL1_11 GDL2_8 GDL2_9
+  GDL2_10 GDL2_11 GDL3_8 GDL3_9 GDL3_10 GDL3_11 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21
+  GDL__22 GDL__23 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN
+  YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMUX_COL_HF
XI3_0 BL0_A_12 BL0_A_13 BL0_A_14 BL0_A_15 BL0_B_12 BL0_B_13 BL0_B_14 BL0_B_15
+  BL0__A_12 BL0__A_13 BL0__A_14 BL0__A_15 BL0__B_12 BL0__B_13 BL0__B_14
+  BL0__B_15 BL1_A_12 BL1_A_13 BL1_A_14 BL1_A_15 BL1_B_12 BL1_B_13 BL1_B_14
+  BL1_B_15 BL1__A_12 BL1__A_13 BL1__A_14 BL1__A_15 BL1__B_12 BL1__B_13
+  BL1__B_14 BL1__B_15 BL2_A_12 BL2_A_13 BL2_A_14 BL2_A_15 BL2_B_12 BL2_B_13
+  BL2_B_14 BL2_B_15 BL2__A_12 BL2__A_13 BL2__A_14 BL2__A_15 BL2__B_12
+  BL2__B_13 BL2__B_14 BL2__B_15 BL3_A_12 BL3_A_13 BL3_A_14 BL3_A_15 BL3_B_12
+  BL3_B_13 BL3_B_14 BL3_B_15 BL3__A_12 BL3__A_13 BL3__A_14 BL3__A_15
+  BL3__B_12 BL3__B_13 BL3__B_14 BL3__B_15 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_12 GDL0_13 GDL0_14
+  GDL0_15 GDL1_12 GDL1_13 GDL1_14 GDL1_15 GDL2_12 GDL2_13 GDL2_14 GDL2_15
+  GDL3_12 GDL3_13 GDL3_14 GDL3_15 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30
+  GDL__31 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI4_0 BL0_A_16 BL0_A_17 BL0_A_18 BL0_A_19 BL0_B_16 BL0_B_17 BL0_B_18 BL0_B_19
+  BL0__A_16 BL0__A_17 BL0__A_18 BL0__A_19 BL0__B_16 BL0__B_17 BL0__B_18
+  BL0__B_19 BL1_A_16 BL1_A_17 BL1_A_18 BL1_A_19 BL1_B_16 BL1_B_17 BL1_B_18
+  BL1_B_19 BL1__A_16 BL1__A_17 BL1__A_18 BL1__A_19 BL1__B_16 BL1__B_17
+  BL1__B_18 BL1__B_19 BL2_A_16 BL2_A_17 BL2_A_18 BL2_A_19 BL2_B_16 BL2_B_17
+  BL2_B_18 BL2_B_19 BL2__A_16 BL2__A_17 BL2__A_18 BL2__A_19 BL2__B_16
+  BL2__B_17 BL2__B_18 BL2__B_19 BL3_A_16 BL3_A_17 BL3_A_18 BL3_A_19 BL3_B_16
+  BL3_B_17 BL3_B_18 BL3_B_19 BL3__A_16 BL3__A_17 BL3__A_18 BL3__A_19
+  BL3__B_16 BL3__B_17 BL3__B_18 BL3__B_19 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_16 GDL0_17 GDL0_18
+  GDL0_19 GDL1_16 GDL1_17 GDL1_18 GDL1_19 GDL2_16 GDL2_17 GDL2_18 GDL2_19
+  GDL3_16 GDL3_17 GDL3_18 GDL3_19 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37
+  GDL_38 GDL_39 GDL__32 GDL__33 GDL__34 GDL__35 GDL__36 GDL__37 GDL__38
+  GDL__39 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI5_0 BL0_A_20 BL0_A_21 BL0_A_22 BL0_A_23 BL0_B_20 BL0_B_21 BL0_B_22 BL0_B_23
+  BL0__A_20 BL0__A_21 BL0__A_22 BL0__A_23 BL0__B_20 BL0__B_21 BL0__B_22
+  BL0__B_23 BL1_A_20 BL1_A_21 BL1_A_22 BL1_A_23 BL1_B_20 BL1_B_21 BL1_B_22
+  BL1_B_23 BL1__A_20 BL1__A_21 BL1__A_22 BL1__A_23 BL1__B_20 BL1__B_21
+  BL1__B_22 BL1__B_23 BL2_A_20 BL2_A_21 BL2_A_22 BL2_A_23 BL2_B_20 BL2_B_21
+  BL2_B_22 BL2_B_23 BL2__A_20 BL2__A_21 BL2__A_22 BL2__A_23 BL2__B_20
+  BL2__B_21 BL2__B_22 BL2__B_23 BL3_A_20 BL3_A_21 BL3_A_22 BL3_A_23 BL3_B_20
+  BL3_B_21 BL3_B_22 BL3_B_23 BL3__A_20 BL3__A_21 BL3__A_22 BL3__A_23
+  BL3__B_20 BL3__B_21 BL3__B_22 BL3__B_23 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_20 GDL0_21 GDL0_22
+  GDL0_23 GDL1_20 GDL1_21 GDL1_22 GDL1_23 GDL2_20 GDL2_21 GDL2_22 GDL2_23
+  GDL3_20 GDL3_21 GDL3_22 GDL3_23 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 GDL__40 GDL__41 GDL__42 GDL__43 GDL__44 GDL__45 GDL__46
+  GDL__47 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI6_0 BL0_A_24 BL0_A_25 BL0_A_26 BL0_A_27 BL0_B_24 BL0_B_25 BL0_B_26 BL0_B_27
+  BL0__A_24 BL0__A_25 BL0__A_26 BL0__A_27 BL0__B_24 BL0__B_25 BL0__B_26
+  BL0__B_27 BL1_A_24 BL1_A_25 BL1_A_26 BL1_A_27 BL1_B_24 BL1_B_25 BL1_B_26
+  BL1_B_27 BL1__A_24 BL1__A_25 BL1__A_26 BL1__A_27 BL1__B_24 BL1__B_25
+  BL1__B_26 BL1__B_27 BL2_A_24 BL2_A_25 BL2_A_26 BL2_A_27 BL2_B_24 BL2_B_25
+  BL2_B_26 BL2_B_27 BL2__A_24 BL2__A_25 BL2__A_26 BL2__A_27 BL2__B_24
+  BL2__B_25 BL2__B_26 BL2__B_27 BL3_A_24 BL3_A_25 BL3_A_26 BL3_A_27 BL3_B_24
+  BL3_B_25 BL3_B_26 BL3_B_27 BL3__A_24 BL3__A_25 BL3__A_26 BL3__A_27
+  BL3__B_24 BL3__B_25 BL3__B_26 BL3__B_27 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_24 GDL0_25 GDL0_26
+  GDL0_27 GDL1_24 GDL1_25 GDL1_26 GDL1_27 GDL2_24 GDL2_25 GDL2_26 GDL2_27
+  GDL3_24 GDL3_25 GDL3_26 GDL3_27 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53
+  GDL_54 GDL_55 GDL__48 GDL__49 GDL__50 GDL__51 GDL__52 GDL__53 GDL__54
+  GDL__55 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI7_0 BL0_A_28 BL0_A_29 BL0_A_30 BL0_A_31 BL0_B_28 BL0_B_29 BL0_B_30 BL0_B_31
+  BL0__A_28 BL0__A_29 BL0__A_30 BL0__A_31 BL0__B_28 BL0__B_29 BL0__B_30
+  BL0__B_31 BL1_A_28 BL1_A_29 BL1_A_30 BL1_A_31 BL1_B_28 BL1_B_29 BL1_B_30
+  BL1_B_31 BL1__A_28 BL1__A_29 BL1__A_30 BL1__A_31 BL1__B_28 BL1__B_29
+  BL1__B_30 BL1__B_31 BL2_A_28 BL2_A_29 BL2_A_30 BL2_A_31 BL2_B_28 BL2_B_29
+  BL2_B_30 BL2_B_31 BL2__A_28 BL2__A_29 BL2__A_30 BL2__A_31 BL2__B_28
+  BL2__B_29 BL2__B_30 BL2__B_31 BL3_A_28 BL3_A_29 BL3_A_30 BL3_A_31 BL3_B_28
+  BL3_B_29 BL3_B_30 BL3_B_31 BL3__A_28 BL3__A_29 BL3__A_30 BL3__A_31
+  BL3__B_28 BL3__B_29 BL3__B_30 BL3__B_31 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_28 GDL0_29 GDL0_30
+  GDL0_31 GDL1_28 GDL1_29 GDL1_30 GDL1_31 GDL2_28 GDL2_29 GDL2_30 GDL2_31
+  GDL3_28 GDL3_29 GDL3_30 GDL3_31 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61
+  GDL_62 GDL_63 GDL__56 GDL__57 GDL__58 GDL__59 GDL__60 GDL__61 GDL__62
+  GDL__63 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI8_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A
+  DRPREN_B SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpCD_EDGE_HF
.ENDS pe_spad_1024x16_dpMUXCOL_ROW_HF_L
****
.SUBCKT pe_spad_1024x16_dpXP_HALF AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AY0TRACK AY1TRACK BLKSELT_A BLKSELT_B BLKSEL_T GSAEN_A GSAEN_B
+  GTPCDNT_A GTPCDNT_B GTPSANT_A GTPSANT_B GTPSA_A GTPSA_B GTPWN_A GTPWN_B
+  RBTPT RRA0 RRA0_ RRA1 RRA1_ TIELO XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9
+  XP10 XP11 XP12 XP13 YP0_0_T YP0_1_T YP0_2_T YP0_3_T YP_T_0_0_AN YP_T_0_0_BN
+  YP_T_0_1_AN YP_T_0_1_BN YP_T_0_2_AN YP_T_0_2_BN YP_T_0_3_AN YP_T_0_3_BN
+  VDDPE VDDCE VSSE
** pe_spad_1024x16_dpXP_HALF: 204 flat devices **
M0 HNET129 AIN3 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I184/N01
M1 NET717 AIN4_ HNET129 VSSE NCH W=3.5U L=0.06U M=1 $name=/I184/N00
M10 VDDPE AINY1 NET679 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I141/P10
M100 VSSE NET674 NET636 VSSE NCH W=2.5U L=0.06U M=1 $name=/N13/N00
M101 NET636 NET0503 BLKSEL_T VSSE NCH W=3U L=0.06U M=1 $name=/N14/N00
M102 TIELO TIEHI VSSE VSSE NCH W=5.1U L=0.06U M=1 $name=/tlo/N00
M103 TIELO TIELO VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N3/N00
M104 NET785 AX1TRACK VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I195/N00
M105 VDDPE AX1TRACK NET785 VDDCE PCH W=1.5U L=0.06U M=1 $name=/I195/P00
M106 AIN3 AX3TRACK VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I189/N00
M107 VDDPE AX3TRACK AIN3 VDDCE PCH W=3.75U L=0.06U M=1 $name=/I189/P00
M108 AIN1_ NET785 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I196/N00
M109 VDDPE NET785 AIN1_ VDDCE PCH W=3.75U L=0.06U M=1 $name=/I196/P00
M11 VDDPE AINY0_ NET679 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I141/P00
M110 AIN1 AX1TRACK VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I197/N00
M111 VDDPE AX1TRACK AIN1 VDDCE PCH W=3.75U L=0.06U M=1 $name=/I197/P00
M112 NET739 AX0TRACK VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I198/N00
M113 VDDPE AX0TRACK NET739 VDDCE PCH W=1.5U L=0.06U M=1 $name=/I198/P00
M114 AIN0_ NET739 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I199/N00
M115 VDDPE NET739 AIN0_ VDDCE PCH W=3.75U L=0.06U M=1 $name=/I199/P00
M116 AIN0 AX0TRACK VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I200/N00
M117 VDDPE AX0TRACK AIN0 VDDCE PCH W=3.75U L=0.06U M=1 $name=/I200/P00
M118 NET775 AX5TRACK VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I30/N00
M119 VDDPE AX5TRACK NET775 VDDCE PCH W=1.5U L=0.06U M=1 $name=/I30/P00
M12 HNET144 AINY0 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I142/N01
M120 NET662 NET0540 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I169/N00
M121 VDDPE NET0540 NET662 VDDCE PCH W=1.08U L=0.06U M=1 $name=/I169/P00
M122 YP0_1_T NET615 VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/I171/N00
M123 VDDPE NET615 YP0_1_T VDDCE PCH W=7U L=0.06U M=1 $name=/I171/P00
M124 YP0_0_T NET621 VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/I172/N00
M125 VDDPE NET621 YP0_0_T VDDCE PCH W=7U L=0.06U M=1 $name=/I172/P00
M126 YP0_2_T NET630 VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/I173/N00
M127 VDDPE NET630 YP0_2_T VDDCE PCH W=7U L=0.06U M=1 $name=/I173/P00
M128 YP0_3_T NET636 VSSE VSSE NCH W=4.2U L=0.06U M=1 $name=/I174/N00
M129 VDDPE NET636 YP0_3_T VDDCE PCH W=7U L=0.06U M=1 $name=/I174/P00
M13 NET677 AINY1 HNET144 VSSE NCH W=0.9U L=0.06U M=1 $name=/I142/N00
M130 NET672 NET0528 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I176/N00
M131 VDDPE NET0528 NET672 VDDCE PCH W=1.08U L=0.06U M=1 $name=/I176/P00
M132 NET674 NET0503 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I177/N00
M133 VDDPE NET0503 NET674 VDDCE PCH W=1.08U L=0.06U M=1 $name=/I177/P00
M134 NET0540 NET691 VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/I150/N00
M135 VDDPE NET691 NET0540 VDDCE PCH W=2U L=0.06U M=1 $name=/I150/P00
M136 NET0482 NET689 VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/I149/N00
M137 VDDPE NET689 NET0482 VDDCE PCH W=2U L=0.06U M=1 $name=/I149/P00
M138 NET685 AY0TRACK VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I152/N00
M139 VDDPE AY0TRACK NET685 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I152/P00
M14 VDDPE AINY0 NET677 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I142/P10
M140 AINY1_ NET699 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I151/N00
M141 VDDPE NET699 AINY1_ VDDCE PCH W=0.8U L=0.06U M=1 $name=/I151/P00
M142 AINY1 AY1TRACK VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I156/N00
M143 VDDPE AY1TRACK AINY1 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I156/P00
M144 NET686 NET0482 VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I168/N00
M145 VDDPE NET0482 NET686 VDDCE PCH W=1.08U L=0.06U M=1 $name=/I168/P00
M146 NET0503 NET677 VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/I155/N00
M147 VDDPE NET677 NET0503 VDDCE PCH W=2U L=0.06U M=1 $name=/I155/P00
M148 NET0528 NET679 VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/I154/N00
M149 VDDPE NET679 NET0528 VDDCE PCH W=2U L=0.06U M=1 $name=/I154/P00
M15 VDDPE AINY1 NET677 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I142/P00
M150 AIN4_ NET759 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I187/N00
M151 VDDPE NET759 AIN4_ VDDCE PCH W=3.75U L=0.06U M=1 $name=/I187/P00
M152 AINY0 AY0TRACK VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I157/N00
M153 VDDPE AY0TRACK AINY0 VDDCE PCH W=0.8U L=0.06U M=1 $name=/I157/P00
M154 AINY0_ NET685 VSSE VSSE NCH W=0.4U L=0.06U M=1 $name=/I158/N00
M155 VDDPE NET685 AINY0_ VDDCE PCH W=0.8U L=0.06U M=1 $name=/I158/P00
M156 XP13 NET701 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I130/N00
M157 VDDPE NET701 XP13 VDDCE PCH W=8U L=0.06U M=1 $name=/I130/P00
M158 XP12 NET703 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I129/N00
M159 VDDPE NET703 XP12 VDDCE PCH W=8U L=0.06U M=1 $name=/I129/P00
M16 HNET149 AINY1_ VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I144/N01
M160 XP11 NET713 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I181/N00
M161 VDDPE NET713 XP11 VDDCE PCH W=8U L=0.06U M=1 $name=/I181/P00
M162 XP10 NET715 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I113/N00
M163 VDDPE NET715 XP10 VDDCE PCH W=8U L=0.06U M=1 $name=/I113/P00
M164 XP9 NET717 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I112/N00
M165 VDDPE NET717 XP9 VDDCE PCH W=8U L=0.06U M=1 $name=/I112/P00
M166 XP8 NET719 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I111/N00
M167 VDDPE NET719 XP8 VDDCE PCH W=8U L=0.06U M=1 $name=/I111/P00
M168 XP4 NET721 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I94/N00
M169 VDDPE NET721 XP4 VDDCE PCH W=8U L=0.06U M=1 $name=/I94/P00
M17 NET691 AINY0_ HNET149 VSSE NCH W=0.9U L=0.06U M=1 $name=/I144/N00
M170 XP7 NET723 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I96/N00
M171 VDDPE NET723 XP7 VDDCE PCH W=8U L=0.06U M=1 $name=/I96/P00
M172 XP5 NET725 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I95/N00
M173 VDDPE NET725 XP5 VDDCE PCH W=8U L=0.06U M=1 $name=/I95/P00
M174 NET699 AY1TRACK VSSE VSSE NCH W=0.2U L=0.06U M=1 $name=/I153/N00
M175 VDDPE AY1TRACK NET699 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I153/P00
M176 AIN6_ NET775 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I34/N00
M177 VDDPE NET775 AIN6_ VDDCE PCH W=3.75U L=0.06U M=1 $name=/I34/P00
M178 XP0 NET737 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I90/N00
M179 VDDPE NET737 XP0 VDDCE PCH W=8U L=0.06U M=1 $name=/I90/P00
M18 VDDPE AINY1_ NET691 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I144/P10
M180 AIN4 AX4TRACK VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I188/N00
M181 VDDPE AX4TRACK AIN4 VDDCE PCH W=3.75U L=0.06U M=1 $name=/I188/P00
M182 AIN3_ NET747 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I190/N00
M183 VDDPE NET747 AIN3_ VDDCE PCH W=3.75U L=0.06U M=1 $name=/I190/P00
M184 AIN2_ NET783 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I193/N00
M185 VDDPE NET783 AIN2_ VDDCE PCH W=3.75U L=0.06U M=1 $name=/I193/P00
M186 XP1 NET773 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I91/N00
M187 VDDPE NET773 XP1 VDDCE PCH W=8U L=0.06U M=1 $name=/I91/P00
M188 NET759 AX4TRACK VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I186/N00
M189 VDDPE AX4TRACK NET759 VDDCE PCH W=1.5U L=0.06U M=1 $name=/I186/P00
M19 VDDPE AINY0_ NET691 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I144/P00
M190 AIN6 AX5TRACK VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I110/N00
M191 VDDPE AX5TRACK AIN6 VDDCE PCH W=3.75U L=0.06U M=1 $name=/I110/P00
M192 XP3 NET777 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I93/N00
M193 VDDPE NET777 XP3 VDDCE PCH W=8U L=0.06U M=1 $name=/I93/P00
M194 XP2 NET779 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I92/N00
M195 VDDPE NET779 XP2 VDDCE PCH W=8U L=0.06U M=1 $name=/I92/P00
M196 XP6 NET781 VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I97/N00
M197 VDDPE NET781 XP6 VDDCE PCH W=8U L=0.06U M=1 $name=/I97/P00
M198 AIN2 AX2TRACK VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/I194/N00
M199 VDDPE AX2TRACK AIN2 VDDCE PCH W=3.75U L=0.06U M=1 $name=/I194/P00
M2 VDDPE AIN3 NET717 VDDCE PCH W=2U L=0.06U M=1 $name=/I184/P10
M20 HNET154 AINY0 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I143/N01
M200 NET783 AX2TRACK VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I192/N00
M201 VDDPE AX2TRACK NET783 VDDCE PCH W=1.5U L=0.06U M=1 $name=/I192/P00
M202 NET747 AX3TRACK VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I191/N00
M203 VDDPE AX3TRACK NET747 VDDCE PCH W=1.5U L=0.06U M=1 $name=/I191/P00
M21 NET689 AINY1_ HNET154 VSSE NCH W=0.9U L=0.06U M=1 $name=/I143/N00
M22 VDDPE AINY0 NET689 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I143/P10
M23 VDDPE AINY1_ NET689 VDDCE PCH W=0.5U L=0.06U M=1 $name=/I143/P00
M24 HNET159 AIN6 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I83/N01
M25 NET701 TIEHI HNET159 VSSE NCH W=3.5U L=0.06U M=1 $name=/I83/N00
M26 VDDPE AIN6 NET701 VDDCE PCH W=2U L=0.06U M=1 $name=/I83/P10
M27 VDDPE TIEHI NET701 VDDCE PCH W=2U L=0.06U M=1 $name=/I83/P00
M28 HNET164 TIEHI VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I82/N01
M29 NET703 AIN6_ HNET164 VSSE NCH W=3.5U L=0.06U M=1 $name=/I82/N00
M3 VDDPE AIN4_ NET717 VDDCE PCH W=2U L=0.06U M=1 $name=/I184/P00
M30 VDDPE TIEHI NET703 VDDCE PCH W=2U L=0.06U M=1 $name=/I82/P10
M31 VDDPE AIN6_ NET703 VDDCE PCH W=2U L=0.06U M=1 $name=/I82/P00
M32 HNET169 AIN4 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I182/N01
M33 NET715 AIN3_ HNET169 VSSE NCH W=3.5U L=0.06U M=1 $name=/I182/N00
M34 VDDPE AIN4 NET715 VDDCE PCH W=2U L=0.06U M=1 $name=/I182/P10
M35 VDDPE AIN3_ NET715 VDDCE PCH W=2U L=0.06U M=1 $name=/I182/P00
M36 HNET174 AIN3 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I180/N01
M37 NET713 AIN4 HNET174 VSSE NCH W=3.5U L=0.06U M=1 $name=/I180/N00
M38 VDDPE AIN3 NET713 VDDCE PCH W=2U L=0.06U M=1 $name=/I180/P10
M39 VDDPE AIN4 NET713 VDDCE PCH W=2U L=0.06U M=1 $name=/I180/P00
M4 HNET134 AIN4_ VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I185/N01
M40 HNET180 AIN2_ VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/gnandbs/N02
M41 HNET181 AIN1_ HNET180 VSSE NCH W=3.5U L=0.06U M=1 $name=/gnandbs/N01
M42 NET737 AIN0_ HNET181 VSSE NCH W=3.5U L=0.06U M=1 $name=/gnandbs/N00
M43 VDDPE AIN2_ NET737 VDDCE PCH W=2U L=0.06U M=1 $name=/gnandbs/P20
M44 VDDPE AIN1_ NET737 VDDCE PCH W=2U L=0.06U M=1 $name=/gnandbs/P10
M45 VDDPE AIN0_ NET737 VDDCE PCH W=2U L=0.06U M=1 $name=/gnandbs/P00
M46 HNET186 AIN0 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I56/N02
M47 HNET187 AIN1 HNET186 VSSE NCH W=3.5U L=0.06U M=1 $name=/I56/N01
M48 NET723 AIN2 HNET187 VSSE NCH W=3.5U L=0.06U M=1 $name=/I56/N00
M49 VDDPE AIN0 NET723 VDDCE PCH W=2U L=0.06U M=1 $name=/I56/P20
M5 NET719 AIN3_ HNET134 VSSE NCH W=3.5U L=0.06U M=1 $name=/I185/N00
M50 VDDPE AIN1 NET723 VDDCE PCH W=2U L=0.06U M=1 $name=/I56/P10
M51 VDDPE AIN2 NET723 VDDCE PCH W=2U L=0.06U M=1 $name=/I56/P00
M52 HNET192 AIN0 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I55/N02
M53 HNET193 AIN1_ HNET192 VSSE NCH W=3.5U L=0.06U M=1 $name=/I55/N01
M54 NET725 AIN2 HNET193 VSSE NCH W=3.5U L=0.06U M=1 $name=/I55/N00
M55 VDDPE AIN0 NET725 VDDCE PCH W=2U L=0.06U M=1 $name=/I55/P20
M56 VDDPE AIN1_ NET725 VDDCE PCH W=2U L=0.06U M=1 $name=/I55/P10
M57 VDDPE AIN2 NET725 VDDCE PCH W=2U L=0.06U M=1 $name=/I55/P00
M58 HNET198 AIN2 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I54/N02
M59 HNET199 AIN1_ HNET198 VSSE NCH W=3.5U L=0.06U M=1 $name=/I54/N01
M6 VDDPE AIN4_ NET719 VDDCE PCH W=2U L=0.06U M=1 $name=/I185/P10
M60 NET721 AIN0_ HNET199 VSSE NCH W=3.5U L=0.06U M=1 $name=/I54/N00
M61 VDDPE AIN2 NET721 VDDCE PCH W=2U L=0.06U M=1 $name=/I54/P20
M62 VDDPE AIN1_ NET721 VDDCE PCH W=2U L=0.06U M=1 $name=/I54/P10
M63 VDDPE AIN0_ NET721 VDDCE PCH W=2U L=0.06U M=1 $name=/I54/P00
M64 HNET204 AIN2_ VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I53/N02
M65 HNET205 AIN1 HNET204 VSSE NCH W=3.5U L=0.06U M=1 $name=/I53/N01
M66 NET779 AIN0_ HNET205 VSSE NCH W=3.5U L=0.06U M=1 $name=/I53/N00
M67 VDDPE AIN2_ NET779 VDDCE PCH W=2U L=0.06U M=1 $name=/I53/P20
M68 VDDPE AIN1 NET779 VDDCE PCH W=2U L=0.06U M=1 $name=/I53/P10
M69 VDDPE AIN0_ NET779 VDDCE PCH W=2U L=0.06U M=1 $name=/I53/P00
M7 VDDPE AIN3_ NET719 VDDCE PCH W=2U L=0.06U M=1 $name=/I185/P00
M70 HNET210 AIN0 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I52/N02
M71 HNET211 AIN1 HNET210 VSSE NCH W=3.5U L=0.06U M=1 $name=/I52/N01
M72 NET777 AIN2_ HNET211 VSSE NCH W=3.5U L=0.06U M=1 $name=/I52/N00
M73 VDDPE AIN0 NET777 VDDCE PCH W=2U L=0.06U M=1 $name=/I52/P20
M74 VDDPE AIN1 NET777 VDDCE PCH W=2U L=0.06U M=1 $name=/I52/P10
M75 VDDPE AIN2_ NET777 VDDCE PCH W=2U L=0.06U M=1 $name=/I52/P00
M76 HNET216 AIN0 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I49/N02
M77 HNET217 AIN1_ HNET216 VSSE NCH W=3.5U L=0.06U M=1 $name=/I49/N01
M78 NET773 AIN2_ HNET217 VSSE NCH W=3.5U L=0.06U M=1 $name=/I49/N00
M79 VDDPE AIN0 NET773 VDDCE PCH W=2U L=0.06U M=1 $name=/I49/P20
M8 HNET139 AINY1 VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I141/N01
M80 VDDPE AIN1_ NET773 VDDCE PCH W=2U L=0.06U M=1 $name=/I49/P10
M81 VDDPE AIN2_ NET773 VDDCE PCH W=2U L=0.06U M=1 $name=/I49/P00
M82 HNET222 AIN2 VSSE VSSE NCH W=3.5U L=0.06U M=1 $name=/I57/N02
M83 HNET223 AIN1 HNET222 VSSE NCH W=3.5U L=0.06U M=1 $name=/I57/N01
M84 NET781 AIN0_ HNET223 VSSE NCH W=3.5U L=0.06U M=1 $name=/I57/N00
M85 VDDPE AIN2 NET781 VDDCE PCH W=2U L=0.06U M=1 $name=/I57/P20
M86 VDDPE AIN1 NET781 VDDCE PCH W=2U L=0.06U M=1 $name=/I57/P10
M87 VDDPE AIN0_ NET781 VDDCE PCH W=2U L=0.06U M=1 $name=/I57/P00
M88 BLKSEL_T NET686 NET615 VDDCE PCH W=3U L=0.06U M=1 $name=/P5/P00
M89 NET621 NET662 BLKSEL_T VDDCE PCH W=3U L=0.06U M=1 $name=/P6/P00
M9 NET679 AINY0_ HNET139 VSSE NCH W=0.9U L=0.06U M=1 $name=/I141/N00
M90 NET630 NET672 BLKSEL_T VDDCE PCH W=3U L=0.06U M=1 $name=/P7/P00
M91 BLKSEL_T NET674 NET636 VDDCE PCH W=3U L=0.06U M=1 $name=/P8/P00
M92 VDDPE TIEHI TIEHI VDDCE PCH W=0.3U L=0.06U M=1 $name=/P2/P00
M93 VDDPE TIELO TIEHI VDDCE PCH W=0.3U L=0.06U M=1 $name=/P1/P00
M94 NET615 NET0482 BLKSEL_T VSSE NCH W=3U L=0.06U M=1 $name=/N7/N00
M95 VSSE NET686 NET615 VSSE NCH W=2.5U L=0.06U M=1 $name=/N8/N00
M96 NET621 NET662 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/N9/N00
M97 BLKSEL_T NET0540 NET621 VSSE NCH W=3U L=0.06U M=1 $name=/N10/N00
M98 BLKSEL_T NET0528 NET630 VSSE NCH W=3U L=0.06U M=1 $name=/N11/N00
M99 NET630 NET672 VSSE VSSE NCH W=2.5U L=0.06U M=1 $name=/N12/N00
.ENDS pe_spad_1024x16_dpXP_HALF
****
.SUBCKT pe_spad_1024x16_dpXPX1_L AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AY0TRACK AY1TRACK BLKSELT_A BLKSELT_B GSAEN_A GSAEN_B GTPCDNT_A
+  GTPCDNT_B GTPSANT_A GTPSANT_B GTPSA_A GTPSA_B GTPWN_A GTPWN_B RBTPT RRA0
+  RRA0_ RRA1 RRA1_ TIELO XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 YP_T_0_0_AN YP_T_0_0_BN YP_T_0_1_AN YP_T_0_1_BN YP_T_0_2_AN
+  YP_T_0_2_BN YP_T_0_3_AN YP_T_0_3_BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpXPX1_L: 204 flat devices **
XI0_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BLKSELT_A BLKSELT_B BLKSELT_A GSAEN_A GSAEN_B GTPCDNT_A GTPCDNT_B GTPSANT_A
+  GTPSANT_B GTPSA_A GTPSA_B GTPWN_A GTPWN_B RBTPT RRA0 RRA0_ RRA1 RRA1_ TIELO
+  XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 YP_T_0_0_AN
+  YP_T_0_1_AN YP_T_0_2_AN YP_T_0_3_AN YP_T_0_0_AN YP_T_0_0_BN YP_T_0_1_AN
+  YP_T_0_1_BN YP_T_0_2_AN YP_T_0_2_BN YP_T_0_3_AN YP_T_0_3_BN VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpXP_HALF
.ENDS pe_spad_1024x16_dpXPX1_L
****
.SUBCKT pe_spad_1024x16_dpCK_HALF BLKSELT BLKSELT_A BLKSELT_B BS0N BS0NT BS1N
+  BS1NT BS2N BS2NT BSAEN_A BSAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT
+  BTPWN_A BTPWN_B BTP_AT BTP_BT DRPREN_AT DRPREN_BT GSAEN GSAEN_A GSAEN_B GTP
+  GTPCDNT GTPCDNT_A GTPCDNT_B GTPD GTPDE GTPDET GTPDT GTPSA GTPSANT GTPSANT_A
+  GTPSANT_B GTPSA_A GTPSA_B GTPT GTPWN GTPWN_A GTPWN_B LGWE LGWET MBL MGDLE
+  MGDLET MGDLS MGDLST MGTPS MGTPST RBTPWDT RDTN RET RREN RRENT TIEHI TIELO
+  WBT YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B
+  YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCK_HALF: 201 flat devices **
M0 HNET138 BSELN VSSE VSSE NCH W=0.6U L=0.06U M=1 $name=/I94/N01
M1 NET366 RREN HNET138 VSSE NCH W=0.6U L=0.06U M=1 $name=/I94/N00
M10 VDDPE GTPD NET585 VDDCE PCH W=1.4U L=0.06U M=1 $name=/gnd2lat/P10
M100 NET456 GTPSA_B VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I27/N00
M101 VDDPE GTPSA_B NET456 VDDCE PCH W=9U L=0.06U M=1 $name=/I27/P00
M102 BTPSA_A NET400 VSSE VSSE NCH W=14U L=0.06U M=1 $name=/I25/N00
M103 VDDPE NET400 BTPSA_A VDDCE PCH W=21U L=0.06U M=1 $name=/I25/P00
M104 NET475 RGTP_WDT VSSE VSSE NCH W=1.96U L=0.06U M=1 $name=/gbtpwdpdrv/N00
M105 VDDPE RGTP_WDT NET475 VDDCE PCH W=3.92U L=0.06U M=1 $name=/gbtpwdpdrv/P00
M106 BTPT_A GTPSANT_A VSSE VSSE NCH W=12U L=0.06U M=1 $name=/I18/N00
M107 VDDPE GTPSANT_A BTPT_A VDDCE PCH W=19.8U L=0.06U M=1 $name=/I18/P00
M108 BTPSA_B NET456 VSSE VSSE NCH W=14U L=0.06U M=1 $name=/I26/N00
M109 VDDPE NET456 BTPSA_B VDDCE PCH W=21U L=0.06U M=1 $name=/I26/P00
M11 VDDPE NET371 NET585 VDDCE PCH W=1.4U L=0.06U M=1 $name=/gnd2lat/P00
M110 BSAEN_A NET410 VSSE VSSE NCH W=14U L=0.06U M=1 $name=/I31/N00
M111 VDDPE NET410 BSAEN_A VDDCE PCH W=21U L=0.06U M=1 $name=/I31/P00
M112 BTPWN_A NET470 VSSE VSSE NCH W=14U L=0.06U M=1 $name=/I35/N00
M113 VDDPE NET470 BTPWN_A VDDCE PCH W=21U L=0.06U M=1 $name=/I35/P00
M114 NET470 GTPWN_A VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I34/N00
M115 VDDPE GTPWN_A NET470 VDDCE PCH W=9U L=0.06U M=1 $name=/I34/P00
M116 NET516 NET0620 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I95/N00
M117 VDDPE NET0620 NET516 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I95/P00
M118 RBTPWDT NET475 VSSE VSSE NCH W=5.8U L=0.06U M=1 $name=/I96/N00
M119 VDDPE NET475 RBTPWDT VDDCE PCH W=8U L=0.06U M=1 $name=/I96/P00
M12 HNET153 PBTPWNT VSSE VSSE NCH W=2U L=0.06U M=1 $name=/ggtpwnd/N01
M120 DRPREN_AT GTPCDNT_A VSSE VSSE NCH W=8U L=0.06U M=1 $name=/I45/N00
M121 VDDPE GTPCDNT_A DRPREN_AT VDDCE PCH W=12U L=0.06U M=1 $name=/I45/P00
M122 DRPREN_BT GTPCDNT_B VSSE VSSE NCH W=8U L=0.06U M=1 $name=/I46/N00
M123 VDDPE GTPCDNT_B DRPREN_BT VDDCE PCH W=12U L=0.06U M=1 $name=/I46/P00
M124 VSSE RET BTPWDT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N1/N00
M125 VSSE RET DRPREN_BT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N21/N00
M126 VSSE RET BTP_AT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N22/N00
M127 VSSE RET BTP_BT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N23/N00
M128 VSSE RET RBTPWDT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N32/N00
M129 VSSE RET MGDLS VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N7/N00
M13 NET375 PBTPWNB HNET153 VSSE NCH W=2U L=0.06U M=1 $name=/ggtpwnd/N00
M130 VSSE RET BTPSA_A VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N10/N00
M131 VSSE RET BTPSA_B VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N14/N00
M132 VSSE RET BTPT_A VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N8/N00
M133 VSSE RET BTPT_B VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N9/N00
M134 VSSE RET DRPREN_AT VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N20/N00
M135 RGTP_WDT NET0620 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N34/N00
M136 RGTP_WDT NET516 GTP VSSE NCH W=0.84U L=0.06U M=1 $name=/N33/N00
M137 NET371 NET519 NET524 VSSE NCH W=1U L=0.06U M=1 $name=/N16/N00
M138 NET524 NET585 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N18/N00
M139 TIELO TIELO TIELO VSSE NCH W=6U L=0.17U M=1 $name=/tsdpd/N00
M14 VDDPE PBTPWNT NET375 VDDCE PCH W=2U L=0.06U M=1 $name=/ggtpwnd/P10
M140 NET371 NET402 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tsasetn1/N00
M141 NET371 NET519 NET536 VSSE NCH W=1U L=0.06U M=1 $name=/tsasetn/N00
M142 NET536 NET585 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tsasetn2/N00
M143 GTP_WDT NET624 GTP VSSE NCH W=0.84U L=0.06U M=1 $name=/tnbtpwdpass/N00
M144 GTP_CDT GTPCDENT GTP VSSE NCH W=1.88U L=0.06U M=1 $name=/tnbtppass/N00
M145 TIELO TIEHI VSSE VSSE NCH W=10.38U L=0.06U M=1 $name=/tlo/N00
M146 GTP_WDT NET436 VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/tbtpwdpd/N00
M147 GTP_CDT SASELT VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/tbtppd/N00
M148 TIELO TIELO VSSE VSSE NCH W=0.3U L=0.06U M=1 $name=/N6/N00
M149 VSSE MGDLE VSSE VSSE NCH W=0.97U L=0.06U M=1 $name=/N5/N00
M15 VDDPE PBTPWNB NET375 VDDCE PCH W=2U L=0.06U M=1 $name=/ggtpwnd/P00
M150 MGDLE TIELO VSSE VSSE NCH W=5U L=0.06U M=1 $name=/N4/N00
M151 VSSE GTPDE VSSE VSSE NCH W=1U L=0.06U M=1 $name=/N31/N00
M152 VSSE MGDLS VSSE VSSE NCH W=0.97U L=0.06U M=1 $name=/N3/N00
M153 MGDLS TIELO VSSE VSSE NCH W=5U L=0.06U M=1 $name=/N2/N00
M154 GTP_CDB SASELB VSSE VSSE NCH W=0.5U L=0.06U M=1 $name=/N13/N00
M155 GTP_CDB GTPCDENB GTP VSSE NCH W=1.88U L=0.06U M=1 $name=/N12/N00
M156 RGTP_WDT NET0620 GTP VDDCE PCH W=1.68U L=0.06U M=1 $name=/P12/P00
M157 NET586 NET402 VDDPE VDDCE PCH W=2U L=0.06U M=1 $name=/P9/P00
M158 NET586 NET402 VDDPE VDDCE PCH W=2U L=0.06U M=1 $name=/tsasetp/P00
M159 NET371 NET585 NET586 VDDCE PCH W=2U L=0.06U M=1 $name=/tsasetp2/P00
M16 HNET158 LGWETD VSSE VSSE NCH W=1.4U L=0.06U M=1 $name=/gbtpwn/N01
M160 NET371 NET519 NET586 VDDCE PCH W=2U L=0.06U M=1 $name=/tsasetp1/P00
M161 GTP_WDT NET436 GTP VDDCE PCH W=1.69U L=0.06U M=1 $name=/tpbtpwdpass/P00
M162 GTP_CDT SASELT GTP VDDCE PCH W=1.88U L=0.06U M=1 $name=/tpbtppass/P00
M163 GTP_CDB SASELB GTP VDDCE PCH W=1.88U L=0.06U M=1 $name=/P7/P00
M164 VDDPE TIELO TIEHI VDDCE PCH W=10.44U L=0.06U M=1 $name=/P3/P00
M165 VDDPE TIEHI TIEHI VDDCE PCH W=0.3U L=0.06U M=1 $name=/P2/P00
M166 VDDPE GTPDE VDDPE VDDCE PCH W=1U L=0.06U M=1 $name=/P13/P00
M167 VDDPE MGDLE VDDPE VDDCE PCH W=1.17U L=0.06U M=1 $name=/P1/P00
M168 VDDPE MGDLS VDDPE VDDCE PCH W=1.17U L=0.06U M=1 $name=/P0/P00
M169 NET615 NET616 VSSE VSSE NCH_HVT W=1.1U L=0.06U M=1 $name=/I0/N00
M17 PBTPWNT NET377 HNET158 VSSE NCH W=1.4U L=0.06U M=1 $name=/gbtpwn/N00
M170 VDDPE NET616 NET615 VDDCE PCH_HVT W=1.8U L=0.06U M=1 $name=/I0/P00
M171 NET616 NET438 VSSE VSSE NCH_HVT W=0.4U L=0.06U M=1 $name=/I1/N00
M172 VDDPE NET438 NET616 VDDCE PCH_HVT W=0.4U L=0.06U M=1 $name=/I1/P00
M173 NET619 NET404 VSSE VSSE NCH_HVT W=0.52U L=0.06U M=1 $name=/grdtinv1/N00
M174 VDDPE NET404 NET619 VDDCE PCH_HVT W=1.04U L=0.06U M=1 $name=/grdtinv1/P00
M175 HNET412 NET615 VSSE VSSE NCH W=2.25U L=0.06U M=1 $name=/ggtpcdntpdrv/N11
M176 NET622 NET438 HNET412 VSSE NCH W=2.25U L=0.06U M=1 $name=/ggtpcdntpdrv/N10
M177 HNET410 NET615 VSSE VSSE NCH W=2.25U L=0.06U M=1 $name=/ggtpcdntpdrv/N01
M178 NET622 NET438 HNET410 VSSE NCH W=2.25U L=0.06U M=1 $name=/ggtpcdntpdrv/N00
M179 VDDPE NET615 NET622 VDDCE PCH W=3.74U L=0.06U M=1 $name=/ggtpcdntpdrv/P10
M18 VDDPE LGWETD PBTPWNT VDDCE PCH W=1.4U L=0.06U M=1 $name=/gbtpwn/P10
M180 VDDPE NET438 NET622 VDDCE PCH W=3.74U L=0.06U M=1 $name=/ggtpcdntpdrv/P00
M181 NET624 NET0620 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tnbst/N10
M182 NET624 BSELN VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/tnbst/N00
M183 VDDPE NET0620 HNET414 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnbst/P01
M184 HNET414 BSELN NET624 VDDCE PCH W=0.6U L=0.06U M=1 $name=/tnbst/P00
M185 NET627 PBTPSAT VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/ggtpsanor/N10
M186 NET627 PBTPSAB VSSE VSSE NCH W=1.2U L=0.06U M=1 $name=/ggtpsanor/N00
M187 VDDPE PBTPSAT HNET418 VDDCE PCH W=4.08U L=0.06U M=1 $name=/ggtpsanor/P01
M188 HNET418 PBTPSAB NET627 VDDCE PCH W=4.08U L=0.06U M=1 $name=/ggtpsanor/P00
M189 PBTPSAB LGWEBD VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I49/N10
M19 VDDPE NET377 PBTPWNT VDDCE PCH W=1.4U L=0.06U M=1 $name=/gbtpwn/P00
M190 PBTPSAB GTPN_CDB VSSE VSSE NCH W=3U L=0.06U M=1 $name=/I49/N00
M191 VDDPE LGWEBD HNET422 VDDCE PCH W=5.1U L=0.06U M=1 $name=/I49/P11
M192 HNET422 GTPN_CDB PBTPSAB VDDCE PCH W=5.1U L=0.06U M=1 $name=/I49/P10
M193 VDDPE LGWEBD HNET424 VDDCE PCH W=5.1U L=0.06U M=1 $name=/I49/P01
M194 HNET424 GTPN_CDB PBTPSAB VDDCE PCH W=5.1U L=0.06U M=1 $name=/I49/P00
M195 PBTPSAT LGWETD VSSE VSSE NCH W=3U L=0.06U M=1 $name=/gbtpsa/N10
M196 PBTPSAT NET438 VSSE VSSE NCH W=3U L=0.06U M=1 $name=/gbtpsa/N00
M197 VDDPE LGWETD HNET427 VDDCE PCH W=5.1U L=0.06U M=1 $name=/gbtpsa/P11
M198 HNET427 NET438 PBTPSAT VDDCE PCH W=5.1U L=0.06U M=1 $name=/gbtpsa/P10
M199 VDDPE LGWETD HNET429 VDDCE PCH W=5.1U L=0.06U M=1 $name=/gbtpsa/P01
M2 VDDPE BSELN NET366 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I94/P10
M20 HNET163 LGWEBD VSSE VSSE NCH W=1.4U L=0.06U M=1 $name=/I48/N01
M200 HNET429 NET438 PBTPSAT VDDCE PCH W=5.1U L=0.06U M=1 $name=/gbtpsa/P00
M21 PBTPWNB NET448 HNET163 VSSE NCH W=1.4U L=0.06U M=1 $name=/I48/N00
M22 VDDPE LGWEBD PBTPWNB VDDCE PCH W=1.4U L=0.06U M=1 $name=/I48/P10
M23 VDDPE NET448 PBTPWNB VDDCE PCH W=1.4U L=0.06U M=1 $name=/I48/P00
M24 HNET168 BS0N VSSE VSSE NCH W=0.91U L=0.06U M=1 $name=/I16/N01
M25 SASELB NET619 HNET168 VSSE NCH W=0.91U L=0.06U M=1 $name=/I16/N00
M26 VDDPE BS0N SASELB VDDCE PCH W=0.91U L=0.06U M=1 $name=/I16/P10
M27 VDDPE NET619 SASELB VDDCE PCH W=0.91U L=0.06U M=1 $name=/I16/P00
M28 HNET173 GTP_WDT VSSE VSSE NCH W=4U L=0.06U M=1 $name=/gbtpwdpredrv/N01
M29 NET395 RREN HNET173 VSSE NCH W=4U L=0.06U M=1 $name=/gbtpwdpredrv/N00
M3 VDDPE RREN NET366 VDDCE PCH W=0.6U L=0.06U M=1 $name=/I94/P00
M30 VDDPE GTP_WDT NET395 VDDCE PCH W=4U L=0.06U M=1 $name=/gbtpwdpredrv/P10
M31 VDDPE RREN NET395 VDDCE PCH W=4U L=0.06U M=1 $name=/gbtpwdpredrv/P00
M32 HNET178 BS2N VSSE VSSE NCH W=1.1U L=0.06U M=1 $name=/I93/N01
M33 BSELN BS1N HNET178 VSSE NCH W=1.1U L=0.06U M=1 $name=/I93/N00
M34 VDDPE BS2N BSELN VDDCE PCH W=0.8U L=0.06U M=1 $name=/I93/P10
M35 VDDPE BS1N BSELN VDDCE PCH W=0.8U L=0.06U M=1 $name=/I93/P00
M36 NET0620 BS0N VSSE VSSE NCH W=0.9U L=0.06U M=1 $name=/I98/N00
M37 VDDPE BS0N NET0620 VDDCE PCH W=1.8U L=0.06U M=1 $name=/I98/P00
M38 BTPWDT NET395 VSSE VSSE NCH W=6U L=0.06U M=1 $name=/gbtpwddrv/N00
M39 VDDPE NET395 BTPWDT VDDCE PCH W=10U L=0.06U M=1 $name=/gbtpwddrv/P00
M4 HNET143 BS0N VSSE VSSE NCH W=0.91U L=0.06U M=1 $name=/gsaselnd/N01
M40 BTPT_B GTPSANT_B VSSE VSSE NCH W=12U L=0.06U M=1 $name=/I19/N00
M41 VDDPE GTPSANT_B BTPT_B VDDCE PCH W=19.8U L=0.06U M=1 $name=/I19/P00
M42 NET519 GTPSA VSSE VSSE NCH W=0.8U L=0.06U M=1 $name=/I9/N00
M43 VDDPE GTPSA NET519 VDDCE PCH W=1.6U L=0.06U M=1 $name=/I9/P00
M44 NET400 GTPSA_A VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I22/N00
M45 VDDPE GTPSA_A NET400 VDDCE PCH W=9U L=0.06U M=1 $name=/I22/P00
M46 NET402 NET366 VSSE VSSE NCH W=1U L=0.06U M=1 $name=/tsaseti/N00
M47 VDDPE NET366 NET402 VDDCE PCH W=2U L=0.06U M=1 $name=/tsaseti/P00
M48 NET404 RDTN VSSE VSSE NCH W=0.22U L=0.06U M=1 $name=/grdtinv2/N00
M49 VDDPE RDTN NET404 VDDCE PCH W=0.45U L=0.06U M=1 $name=/grdtinv2/P00
M5 SASELT NET619 HNET143 VSSE NCH W=0.91U L=0.06U M=1 $name=/gsaselnd/N00
M50 NET406 GSAEN_B VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I32/N00
M51 VDDPE GSAEN_B NET406 VDDCE PCH W=9U L=0.06U M=1 $name=/I32/P00
M52 BSAEN_B NET406 VSSE VSSE NCH W=14U L=0.06U M=1 $name=/I33/N00
M53 VDDPE NET406 BSAEN_B VDDCE PCH W=21U L=0.06U M=1 $name=/I33/P00
M54 NET410 GSAEN_A VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I30/N00
M55 VDDPE GSAEN_A NET410 VDDCE PCH W=9U L=0.06U M=1 $name=/I30/P00
M56 NET412 GTPWN_B VSSE VSSE NCH W=5U L=0.06U M=1 $name=/I36/N00
M57 VDDPE GTPWN_B NET412 VDDCE PCH W=9U L=0.06U M=1 $name=/I36/P00
M58 LGWETD NET418 VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/glgweinv2/N00
M59 VDDPE NET418 LGWETD VDDCE PCH W=4U L=0.06U M=1 $name=/glgweinv2/P00
M6 VDDPE BS0N SASELT VDDCE PCH W=0.91U L=0.06U M=1 $name=/gsaselnd/P10
M60 BTPWN_B NET412 VSSE VSSE NCH W=14U L=0.06U M=1 $name=/I37/N00
M61 VDDPE NET412 BTPWN_B VDDCE PCH W=21U L=0.06U M=1 $name=/I37/P00
M62 NET418 LGWE VSSE VSSE NCH W=1U L=0.06U M=1 $name=/glgweinv1/N00
M63 VDDPE LGWE NET418 VDDCE PCH W=2U L=0.06U M=1 $name=/glgweinv1/P00
M64 BTP_AT GTPCDNT_A VSSE VSSE NCH W=8U L=0.06U M=1 $name=/I61/N00
M65 VDDPE GTPCDNT_A BTP_AT VDDCE PCH W=12U L=0.06U M=1 $name=/I61/P00
M66 GTPWN NET375 VSSE VSSE NCH W=2.25U L=0.06U M=1 $name=/ggtpwdrv/N00
M67 VDDPE NET375 GTPWN VDDCE PCH W=3.8U L=0.06U M=1 $name=/ggtpwdrv/P00
M68 BTP_BT GTPCDNT_B VSSE VSSE NCH W=8U L=0.06U M=1 $name=/I62/N00
M69 VDDPE GTPCDNT_B BTP_BT VDDCE PCH W=12U L=0.06U M=1 $name=/I62/P00
M7 VDDPE NET619 SASELT VDDCE PCH W=0.91U L=0.06U M=1 $name=/gsaselnd/P00
M70 GTPSANT PBTPSAT VSSE VSSE NCH W=5U L=0.06U M=1 $name=/ggtpsantdrv/N00
M71 VDDPE PBTPSAT GTPSANT VDDCE PCH W=8U L=0.06U M=1 $name=/ggtpsantdrv/P00
M72 GTPSA NET627 VSSE VSSE NCH W=2.25U L=0.06U M=1 $name=/ggtpsadrv/N00
M73 VDDPE NET627 GTPSA VDDCE PCH W=3.8U L=0.06U M=1 $name=/ggtpsadrv/P00
M74 GTPCDNT NET622 VSSE VSSE NCH W=6U L=0.06U M=1 $name=/ggtpcdntdrv/N00
M75 VDDPE NET622 GTPCDNT VDDCE PCH W=10U L=0.06U M=1 $name=/ggtpcdntdrv/P00
M76 GSAEN NET371 VSSE VSSE NCH W=2.25U L=0.06U M=1 $name=/ggsaendrv/N00
M77 VDDPE NET371 GSAEN VDDCE PCH W=3.8U L=0.06U M=1 $name=/ggsaendrv/P00
M78 NET377 NET438 VSSE VSSE NCH W=0.64U L=0.06U M=1 $name=/gbtpwinv/N00
M79 VDDPE NET438 NET377 VDDCE PCH W=1.28U L=0.06U M=1 $name=/gbtpwinv/P00
M8 HNET148 GTPD VSSE VSSE NCH W=1.4U L=0.06U M=1 $name=/gnd2lat/N01
M80 NET436 NET624 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gbtpwdinv/N00
M81 VDDPE NET624 NET436 VDDCE PCH W=0.3U L=0.06U M=1 $name=/gbtpwdinv/P00
M82 NET438 GTP_CDT VSSE VSSE NCH W=3.2U L=0.06U M=1 $name=/gbtppdrv/N00
M83 VDDPE GTP_CDT NET438 VDDCE PCH W=5.4U L=0.06U M=1 $name=/gbtppdrv/P00
M84 GTPCDENT SASELT VSSE VSSE NCH W=0.27U L=0.06U M=1 $name=/gbtpinv/N00
M85 VDDPE SASELT GTPCDENT VDDCE PCH W=0.54U L=0.06U M=1 $name=/gbtpinv/P00
M86 NET445 BS0N VSSE VSSE NCH W=2.26U L=0.06U M=1 $name=/gblkselpdrv/N00
M87 VDDPE BS0N NET445 VDDCE PCH W=4.52U L=0.06U M=1 $name=/gblkselpdrv/P00
M88 BLKSELT NET445 VSSE VSSE NCH W=6U L=0.06U M=1 $name=/gblkseldrv/N00
M89 VDDPE NET445 BLKSELT VDDCE PCH W=10U L=0.06U M=1 $name=/gblkseldrv/P00
M9 NET585 NET371 HNET148 VSSE NCH W=1.4U L=0.06U M=1 $name=/gnd2lat/N00
M90 NET455 LGWE VSSE VSSE NCH W=1U L=0.06U M=1 $name=/I66/N00
M91 VDDPE LGWE NET455 VDDCE PCH W=2U L=0.06U M=1 $name=/I66/P00
M92 NET448 GTPN_CDB VSSE VSSE NCH W=0.64U L=0.06U M=1 $name=/I59/N00
M93 VDDPE GTPN_CDB NET448 VDDCE PCH W=1.28U L=0.06U M=1 $name=/I59/P00
M94 GTPCDENB SASELB VSSE VSSE NCH W=0.27U L=0.06U M=1 $name=/I58/N00
M95 VDDPE SASELB GTPCDENB VDDCE PCH W=0.54U L=0.06U M=1 $name=/I58/P00
M96 GTPN_CDB GTP_CDB VSSE VSSE NCH W=3.2U L=0.06U M=1 $name=/I55/N00
M97 VDDPE GTP_CDB GTPN_CDB VDDCE PCH W=5.4U L=0.06U M=1 $name=/I55/P00
M98 LGWEBD NET455 VSSE VSSE NCH W=2.28U L=0.06U M=1 $name=/I53/N00
M99 VDDPE NET455 LGWEBD VDDCE PCH W=4U L=0.06U M=1 $name=/I53/P00
.ENDS pe_spad_1024x16_dpCK_HALF
****
.SUBCKT pe_spad_1024x16_dpCKX1_L_0 BLKSELT BLKSELT_B BS0N BS0NT BS1N BS1NT
+  BS2N BS2NT BSAEN_A BSAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT BTPWN_A
+  BTPWN_B BTP_AT BTP_BT DRPREN_AT DRPREN_BT GSAEN GSAEN_B GTP GTPCDNT
+  GTPCDNT_B GTPD GTPDET GTPDT GTPSA GTPSANT GTPSANT_B GTPSA_B GTPWN GTPWN_B
+  LGWE MBL MGDLE MGDLET MGDLST MGTPS MGTPST RBTPWDT RDTN RET RREN RRENT TIEHI
+  TIELO WBT YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B
+  YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCKX1_L_0: 201 flat devices **
XI0_0 BLKSELT BLKSELT BLKSELT_B BS0N BS0NT BS1N BS1NT BS2N BS2NT BSAEN_A
+  BSAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT BTPWN_A BTPWN_B BTP_AT BTP_BT
+  DRPREN_AT DRPREN_BT GSAEN GSAEN GSAEN_B GTP GTPCDNT GTPCDNT GTPCDNT_B GTPD
+  GTPD GTPDET GTPDT GTPSA GTPSANT GTPSANT GTPSANT_B GTPSA GTPSA_B GTP GTPWN
+  GTPWN GTPWN_B LGWE LGWE MBL MGDLE MGDLET MGDLE MGDLST MGTPS MGTPST RBTPWDT
+  RDTN RET RREN RRENT TIEHI TIELO WBT YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A
+  YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCK_HALF
.ENDS pe_spad_1024x16_dpCKX1_L_0
****
.SUBCKT pe_spad_1024x16_dpBKCTRL_HF_L_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK
+  AX4TRACK AX5TRACK AY0TRACK AY1TRACK BLKSELT_A BLKSELT_B BS0N BS0NT BS1N
+  BS1NT BS2N BS2NT BSAEN_A BSAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT
+  BTPWN_A BTPWN_B BTP_AT BTP_BT DRPREN_AT DRPREN_BT GSAEN_A GSAEN_B GTPCDNT_A
+  GTPCDNT_B GTPD GTPDET GTPDT GTPSANT_A GTPSANT_B GTPSA_A GTPSA_B GTPT
+  GTPWN_A GTPWN_B LGWET MBL MGDLE MGDLET MGDLST MGTPS MGTPST RBTPT RDTN RET
+  RRA0 RRA0_ RRA1 RRA1_ RREN RRENT TIEHI TIELO WBT XP0 XP1 XP2 XP3 XP4 XP5
+  XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A
+  YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpBKCTRL_HF_L_0: 405 flat devices **
XI0_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BLKSELT_A BLKSELT_B GSAEN_A GSAEN_B GTPCDNT_A GTPCDNT_B GTPSANT_A GTPSANT_B
+  GTPSA_A GTPSA_B GTPWN_A GTPWN_B RBTPT RRA0 RRA0_ RRA1 RRA1_ TIELO XP0 XP1
+  XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 YP_T_0_0_A YP_T_0_0_B
+  YP_T_0_1_A YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B YP_T_0_3_A YP_T_0_3_B VDDPE
+  VDDCE VSSE pe_spad_1024x16_dpXPX1_L
XI1_0 BLKSELT_A BLKSELT_B BS0N BS0NT BS1N BS1NT BS2N BS2NT BSAEN_A BSAEN_B
+  BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT BTPWN_A BTPWN_B BTP_AT BTP_BT
+  DRPREN_AT DRPREN_BT GSAEN_A GSAEN_B GTPT GTPCDNT_A GTPCDNT_B GTPD GTPDET
+  GTPDT GTPSA_A GTPSANT_A GTPSANT_B GTPSA_B GTPWN_A GTPWN_B LGWET MBL MGDLE
+  MGDLET MGDLST MGTPS MGTPST RBTPT RDTN RET RREN RRENT TIEHI TIELO WBT
+  YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B
+  YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE pe_spad_1024x16_dpCKX1_L_0
.ENDS pe_spad_1024x16_dpBKCTRL_HF_L_0
****
.SUBCKT pe_spad_1024x16_dpXPX1_R AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AY0TRACK AY1TRACK BLKSELT_A BLKSELT_B GSAEN_A GSAEN_B GTPCDNT_A
+  GTPCDNT_B GTPSANT_A GTPSANT_B GTPSA_A GTPSA_B GTPWN_A GTPWN_B RBTPT RRA0
+  RRA0_ RRA1 RRA1_ TIELO XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 YP_T_0_0_AN YP_T_0_0_BN YP_T_0_1_AN YP_T_0_1_BN YP_T_0_2_AN
+  YP_T_0_2_BN YP_T_0_3_AN YP_T_0_3_BN VDDPE VDDCE VSSE
** pe_spad_1024x16_dpXPX1_R: 204 flat devices **
XI0_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BLKSELT_A BLKSELT_B BLKSELT_B GSAEN_A GSAEN_B GTPCDNT_A GTPCDNT_B GTPSANT_A
+  GTPSANT_B GTPSA_A GTPSA_B GTPWN_A GTPWN_B RBTPT RRA0 RRA0_ RRA1 RRA1_ TIELO
+  XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 YP_T_0_0_BN
+  YP_T_0_1_BN YP_T_0_2_BN YP_T_0_3_BN YP_T_0_0_AN YP_T_0_0_BN YP_T_0_1_AN
+  YP_T_0_1_BN YP_T_0_2_AN YP_T_0_2_BN YP_T_0_3_AN YP_T_0_3_BN VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpXP_HALF
.ENDS pe_spad_1024x16_dpXPX1_R
****
.SUBCKT pe_spad_1024x16_dpCKX1_R_0 BLKSELT BLKSELT_A BS0N BS0NT BS1N BS1NT
+  BS2N BS2NT BSAEN_A BSAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT BTPWN_A
+  BTPWN_B BTP_AT BTP_BT DRPREN_AT DRPREN_BT GSAEN GSAEN_A GTP GTPCDNT
+  GTPCDNT_A GTPD GTPDET GTPDT GTPSA GTPSANT GTPSANT_A GTPSA_A GTPWN GTPWN_A
+  LGWE MBL MGDLE MGDLET MGDLST MGTPS MGTPST RBTPWDT RDTN RET RREN RRENT TIEHI
+  TIELO WBT YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B
+  YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCKX1_R_0: 201 flat devices **
XI0_0 BLKSELT BLKSELT_A BLKSELT BS0N BS0NT BS1N BS1NT BS2N BS2NT BSAEN_A
+  BSAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT BTPWN_A BTPWN_B BTP_AT BTP_BT
+  DRPREN_AT DRPREN_BT GSAEN GSAEN_A GSAEN GTP GTPCDNT GTPCDNT_A GTPCDNT GTPD
+  GTPD GTPDET GTPDT GTPSA GTPSANT GTPSANT_A GTPSANT GTPSA_A GTPSA GTP GTPWN
+  GTPWN_A GTPWN LGWE LGWE MBL MGDLE MGDLET MGDLE MGDLST MGTPS MGTPST RBTPWDT
+  RDTN RET RREN RRENT TIEHI TIELO WBT YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A
+  YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCK_HALF
.ENDS pe_spad_1024x16_dpCKX1_R_0
****
.SUBCKT pe_spad_1024x16_dpBKCTRL_HF_R_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK
+  AX4TRACK AX5TRACK AY0TRACK AY1TRACK BLKSELT_A BLKSELT_B BS0N BS0NT BS1N
+  BS1NT BS2N BS2NT BSAEN_A BSAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT
+  BTPWN_A BTPWN_B BTP_AT BTP_BT DRPREN_AT DRPREN_BT GSAEN_A GSAEN_B GTPCDNT_A
+  GTPCDNT_B GTPD GTPDET GTPDT GTPSANT_A GTPSANT_B GTPSA_A GTPSA_B GTPT
+  GTPWN_A GTPWN_B LGWET MBL MGDLE MGDLET MGDLST MGTPS MGTPST RBTPT RDTN RET
+  RRA0 RRA0_ RRA1 RRA1_ RREN RRENT TIEHI TIELO WBT XP0 XP1 XP2 XP3 XP4 XP5
+  XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A
+  YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE
** pe_spad_1024x16_dpBKCTRL_HF_R_0: 405 flat devices **
XI0_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BLKSELT_A BLKSELT_B GSAEN_A GSAEN_B GTPCDNT_A GTPCDNT_B GTPSANT_A GTPSANT_B
+  GTPSA_A GTPSA_B GTPWN_A GTPWN_B RBTPT RRA0 RRA0_ RRA1 RRA1_ TIELO XP0 XP1
+  XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 YP_T_0_0_A YP_T_0_0_B
+  YP_T_0_1_A YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B YP_T_0_3_A YP_T_0_3_B VDDPE
+  VDDCE VSSE pe_spad_1024x16_dpXPX1_R
XI1_0 BLKSELT_B BLKSELT_A BS0N BS0NT BS1N BS1NT BS2N BS2NT BSAEN_A BSAEN_B
+  BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT BTPWN_A BTPWN_B BTP_AT BTP_BT
+  DRPREN_AT DRPREN_BT GSAEN_B GSAEN_A GTPT GTPCDNT_B GTPCDNT_A GTPD GTPDET
+  GTPDT GTPSA_B GTPSANT_B GTPSANT_A GTPSA_A GTPWN_B GTPWN_A LGWET MBL MGDLE
+  MGDLET MGDLST MGTPS MGTPST RBTPT RDTN RET RREN RRENT TIEHI TIELO WBT
+  YP_T_0_0_A YP_T_0_0_B YP_T_0_1_A YP_T_0_1_B YP_T_0_2_A YP_T_0_2_B
+  YP_T_0_3_A YP_T_0_3_B VDDPE VDDCE VSSE pe_spad_1024x16_dpCKX1_R_0
.ENDS pe_spad_1024x16_dpBKCTRL_HF_R_0
****
.SUBCKT pe_spad_1024x16_dpMUXCOL_ROW_HF_R BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3
+  BL0_A_4 BL0_A_5 BL0_A_6 BL0_A_7 BL0_A_8 BL0_A_9 BL0_A_10 BL0_A_11 BL0_A_12
+  BL0_A_13 BL0_A_14 BL0_A_15 BL0_A_16 BL0_A_17 BL0_A_18 BL0_A_19 BL0_A_20
+  BL0_A_21 BL0_A_22 BL0_A_23 BL0_A_24 BL0_A_25 BL0_A_26 BL0_A_27 BL0_A_28
+  BL0_A_29 BL0_A_30 BL0_A_31 BL0_B_0 BL0_B_1 BL0_B_2 BL0_B_3 BL0_B_4 BL0_B_5
+  BL0_B_6 BL0_B_7 BL0_B_8 BL0_B_9 BL0_B_10 BL0_B_11 BL0_B_12 BL0_B_13
+  BL0_B_14 BL0_B_15 BL0_B_16 BL0_B_17 BL0_B_18 BL0_B_19 BL0_B_20 BL0_B_21
+  BL0_B_22 BL0_B_23 BL0_B_24 BL0_B_25 BL0_B_26 BL0_B_27 BL0_B_28 BL0_B_29
+  BL0_B_30 BL0_B_31 BL0__A_0 BL0__A_1 BL0__A_2 BL0__A_3 BL0__A_4 BL0__A_5
+  BL0__A_6 BL0__A_7 BL0__A_8 BL0__A_9 BL0__A_10 BL0__A_11 BL0__A_12 BL0__A_13
+  BL0__A_14 BL0__A_15 BL0__A_16 BL0__A_17 BL0__A_18 BL0__A_19 BL0__A_20
+  BL0__A_21 BL0__A_22 BL0__A_23 BL0__A_24 BL0__A_25 BL0__A_26 BL0__A_27
+  BL0__A_28 BL0__A_29 BL0__A_30 BL0__A_31 BL0__B_0 BL0__B_1 BL0__B_2 BL0__B_3
+  BL0__B_4 BL0__B_5 BL0__B_6 BL0__B_7 BL0__B_8 BL0__B_9 BL0__B_10 BL0__B_11
+  BL0__B_12 BL0__B_13 BL0__B_14 BL0__B_15 BL0__B_16 BL0__B_17 BL0__B_18
+  BL0__B_19 BL0__B_20 BL0__B_21 BL0__B_22 BL0__B_23 BL0__B_24 BL0__B_25
+  BL0__B_26 BL0__B_27 BL0__B_28 BL0__B_29 BL0__B_30 BL0__B_31 BL1_A_0 BL1_A_1
+  BL1_A_2 BL1_A_3 BL1_A_4 BL1_A_5 BL1_A_6 BL1_A_7 BL1_A_8 BL1_A_9 BL1_A_10
+  BL1_A_11 BL1_A_12 BL1_A_13 BL1_A_14 BL1_A_15 BL1_A_16 BL1_A_17 BL1_A_18
+  BL1_A_19 BL1_A_20 BL1_A_21 BL1_A_22 BL1_A_23 BL1_A_24 BL1_A_25 BL1_A_26
+  BL1_A_27 BL1_A_28 BL1_A_29 BL1_A_30 BL1_A_31 BL1_B_0 BL1_B_1 BL1_B_2
+  BL1_B_3 BL1_B_4 BL1_B_5 BL1_B_6 BL1_B_7 BL1_B_8 BL1_B_9 BL1_B_10 BL1_B_11
+  BL1_B_12 BL1_B_13 BL1_B_14 BL1_B_15 BL1_B_16 BL1_B_17 BL1_B_18 BL1_B_19
+  BL1_B_20 BL1_B_21 BL1_B_22 BL1_B_23 BL1_B_24 BL1_B_25 BL1_B_26 BL1_B_27
+  BL1_B_28 BL1_B_29 BL1_B_30 BL1_B_31 BL1__A_0 BL1__A_1 BL1__A_2 BL1__A_3
+  BL1__A_4 BL1__A_5 BL1__A_6 BL1__A_7 BL1__A_8 BL1__A_9 BL1__A_10 BL1__A_11
+  BL1__A_12 BL1__A_13 BL1__A_14 BL1__A_15 BL1__A_16 BL1__A_17 BL1__A_18
+  BL1__A_19 BL1__A_20 BL1__A_21 BL1__A_22 BL1__A_23 BL1__A_24 BL1__A_25
+  BL1__A_26 BL1__A_27 BL1__A_28 BL1__A_29 BL1__A_30 BL1__A_31 BL1__B_0
+  BL1__B_1 BL1__B_2 BL1__B_3 BL1__B_4 BL1__B_5 BL1__B_6 BL1__B_7 BL1__B_8
+  BL1__B_9 BL1__B_10 BL1__B_11 BL1__B_12 BL1__B_13 BL1__B_14 BL1__B_15
+  BL1__B_16 BL1__B_17 BL1__B_18 BL1__B_19 BL1__B_20 BL1__B_21 BL1__B_22
+  BL1__B_23 BL1__B_24 BL1__B_25 BL1__B_26 BL1__B_27 BL1__B_28 BL1__B_29
+  BL1__B_30 BL1__B_31 BL2_A_0 BL2_A_1 BL2_A_2 BL2_A_3 BL2_A_4 BL2_A_5 BL2_A_6
+  BL2_A_7 BL2_A_8 BL2_A_9 BL2_A_10 BL2_A_11 BL2_A_12 BL2_A_13 BL2_A_14
+  BL2_A_15 BL2_A_16 BL2_A_17 BL2_A_18 BL2_A_19 BL2_A_20 BL2_A_21 BL2_A_22
+  BL2_A_23 BL2_A_24 BL2_A_25 BL2_A_26 BL2_A_27 BL2_A_28 BL2_A_29 BL2_A_30
+  BL2_A_31 BL2_B_0 BL2_B_1 BL2_B_2 BL2_B_3 BL2_B_4 BL2_B_5 BL2_B_6 BL2_B_7
+  BL2_B_8 BL2_B_9 BL2_B_10 BL2_B_11 BL2_B_12 BL2_B_13 BL2_B_14 BL2_B_15
+  BL2_B_16 BL2_B_17 BL2_B_18 BL2_B_19 BL2_B_20 BL2_B_21 BL2_B_22 BL2_B_23
+  BL2_B_24 BL2_B_25 BL2_B_26 BL2_B_27 BL2_B_28 BL2_B_29 BL2_B_30 BL2_B_31
+  BL2__A_0 BL2__A_1 BL2__A_2 BL2__A_3 BL2__A_4 BL2__A_5 BL2__A_6 BL2__A_7
+  BL2__A_8 BL2__A_9 BL2__A_10 BL2__A_11 BL2__A_12 BL2__A_13 BL2__A_14
+  BL2__A_15 BL2__A_16 BL2__A_17 BL2__A_18 BL2__A_19 BL2__A_20 BL2__A_21
+  BL2__A_22 BL2__A_23 BL2__A_24 BL2__A_25 BL2__A_26 BL2__A_27 BL2__A_28
+  BL2__A_29 BL2__A_30 BL2__A_31 BL2__B_0 BL2__B_1 BL2__B_2 BL2__B_3 BL2__B_4
+  BL2__B_5 BL2__B_6 BL2__B_7 BL2__B_8 BL2__B_9 BL2__B_10 BL2__B_11 BL2__B_12
+  BL2__B_13 BL2__B_14 BL2__B_15 BL2__B_16 BL2__B_17 BL2__B_18 BL2__B_19
+  BL2__B_20 BL2__B_21 BL2__B_22 BL2__B_23 BL2__B_24 BL2__B_25 BL2__B_26
+  BL2__B_27 BL2__B_28 BL2__B_29 BL2__B_30 BL2__B_31 BL3_A_0 BL3_A_1 BL3_A_2
+  BL3_A_3 BL3_A_4 BL3_A_5 BL3_A_6 BL3_A_7 BL3_A_8 BL3_A_9 BL3_A_10 BL3_A_11
+  BL3_A_12 BL3_A_13 BL3_A_14 BL3_A_15 BL3_A_16 BL3_A_17 BL3_A_18 BL3_A_19
+  BL3_A_20 BL3_A_21 BL3_A_22 BL3_A_23 BL3_A_24 BL3_A_25 BL3_A_26 BL3_A_27
+  BL3_A_28 BL3_A_29 BL3_A_30 BL3_A_31 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3 BL3_B_4
+  BL3_B_5 BL3_B_6 BL3_B_7 BL3_B_8 BL3_B_9 BL3_B_10 BL3_B_11 BL3_B_12 BL3_B_13
+  BL3_B_14 BL3_B_15 BL3_B_16 BL3_B_17 BL3_B_18 BL3_B_19 BL3_B_20 BL3_B_21
+  BL3_B_22 BL3_B_23 BL3_B_24 BL3_B_25 BL3_B_26 BL3_B_27 BL3_B_28 BL3_B_29
+  BL3_B_30 BL3_B_31 BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3 BL3__A_4 BL3__A_5
+  BL3__A_6 BL3__A_7 BL3__A_8 BL3__A_9 BL3__A_10 BL3__A_11 BL3__A_12 BL3__A_13
+  BL3__A_14 BL3__A_15 BL3__A_16 BL3__A_17 BL3__A_18 BL3__A_19 BL3__A_20
+  BL3__A_21 BL3__A_22 BL3__A_23 BL3__A_24 BL3__A_25 BL3__A_26 BL3__A_27
+  BL3__A_28 BL3__A_29 BL3__A_30 BL3__A_31 BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3
+  BL3__B_4 BL3__B_5 BL3__B_6 BL3__B_7 BL3__B_8 BL3__B_9 BL3__B_10 BL3__B_11
+  BL3__B_12 BL3__B_13 BL3__B_14 BL3__B_15 BL3__B_16 BL3__B_17 BL3__B_18
+  BL3__B_19 BL3__B_20 BL3__B_21 BL3__B_22 BL3__B_23 BL3__B_24 BL3__B_25
+  BL3__B_26 BL3__B_27 BL3__B_28 BL3__B_29 BL3__B_30 BL3__B_31 BTPSA_A BTPSA_B
+  BTPT_A BTPT_B BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_0 GDL0_1
+  GDL0_2 GDL0_3 GDL0_4 GDL0_5 GDL0_6 GDL0_7 GDL0_8 GDL0_9 GDL0_10 GDL0_11
+  GDL0_12 GDL0_13 GDL0_14 GDL0_15 GDL0_16 GDL0_17 GDL0_18 GDL0_19 GDL0_20
+  GDL0_21 GDL0_22 GDL0_23 GDL0_24 GDL0_25 GDL0_26 GDL0_27 GDL0_28 GDL0_29
+  GDL0_30 GDL0_31 GDL1_0 GDL1_1 GDL1_2 GDL1_3 GDL1_4 GDL1_5 GDL1_6 GDL1_7
+  GDL1_8 GDL1_9 GDL1_10 GDL1_11 GDL1_12 GDL1_13 GDL1_14 GDL1_15 GDL1_16
+  GDL1_17 GDL1_18 GDL1_19 GDL1_20 GDL1_21 GDL1_22 GDL1_23 GDL1_24 GDL1_25
+  GDL1_26 GDL1_27 GDL1_28 GDL1_29 GDL1_30 GDL1_31 GDL2_0 GDL2_1 GDL2_2 GDL2_3
+  GDL2_4 GDL2_5 GDL2_6 GDL2_7 GDL2_8 GDL2_9 GDL2_10 GDL2_11 GDL2_12 GDL2_13
+  GDL2_14 GDL2_15 GDL2_16 GDL2_17 GDL2_18 GDL2_19 GDL2_20 GDL2_21 GDL2_22
+  GDL2_23 GDL2_24 GDL2_25 GDL2_26 GDL2_27 GDL2_28 GDL2_29 GDL2_30 GDL2_31
+  GDL3_0 GDL3_1 GDL3_2 GDL3_3 GDL3_4 GDL3_5 GDL3_6 GDL3_7 GDL3_8 GDL3_9
+  GDL3_10 GDL3_11 GDL3_12 GDL3_13 GDL3_14 GDL3_15 GDL3_16 GDL3_17 GDL3_18
+  GDL3_19 GDL3_20 GDL3_21 GDL3_22 GDL3_23 GDL3_24 GDL3_25 GDL3_26 GDL3_27
+  GDL3_28 GDL3_29 GDL3_30 GDL3_31 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6
+  GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17
+  GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27
+  GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37
+  GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47
+  GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57
+  GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL__0 GDL__1 GDL__2 GDL__3
+  GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13
+  GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21 GDL__22
+  GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30 GDL__31
+  GDL__32 GDL__33 GDL__34 GDL__35 GDL__36 GDL__37 GDL__38 GDL__39 GDL__40
+  GDL__41 GDL__42 GDL__43 GDL__44 GDL__45 GDL__46 GDL__47 GDL__48 GDL__49
+  GDL__50 GDL__51 GDL__52 GDL__53 GDL__54 GDL__55 GDL__56 GDL__57 GDL__58
+  GDL__59 GDL__60 GDL__61 GDL__62 GDL__63 SAEN_A SAEN_B TIELO YP0_0_AN
+  YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE
+  VSSE
** pe_spad_1024x16_dpMUXCOL_ROW_HF_R: 6465 flat devices **
XI0_0 BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3 BL0_B_0 BL0_B_1 BL0_B_2 BL0_B_3 BL0__A_0
+  BL0__A_1 BL0__A_2 BL0__A_3 BL0__B_0 BL0__B_1 BL0__B_2 BL0__B_3 BL1_A_0
+  BL1_A_1 BL1_A_2 BL1_A_3 BL1_B_0 BL1_B_1 BL1_B_2 BL1_B_3 BL1__A_0 BL1__A_1
+  BL1__A_2 BL1__A_3 BL1__B_0 BL1__B_1 BL1__B_2 BL1__B_3 BL2_A_0 BL2_A_1
+  BL2_A_2 BL2_A_3 BL2_B_0 BL2_B_1 BL2_B_2 BL2_B_3 BL2__A_0 BL2__A_1 BL2__A_2
+  BL2__A_3 BL2__B_0 BL2__B_1 BL2__B_2 BL2__B_3 BL3_A_0 BL3_A_1 BL3_A_2
+  BL3_A_3 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3 BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3
+  BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_0 GDL0_1 GDL0_2 GDL0_3 GDL1_0
+  GDL1_1 GDL1_2 GDL1_3 GDL2_0 GDL2_1 GDL2_2 GDL2_3 GDL3_0 GDL3_1 GDL3_2
+  GDL3_3 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL__0 GDL__1 GDL__2
+  GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMUX_COL_HF
XI1_0 BL0_A_4 BL0_A_5 BL0_A_6 BL0_A_7 BL0_B_4 BL0_B_5 BL0_B_6 BL0_B_7 BL0__A_4
+  BL0__A_5 BL0__A_6 BL0__A_7 BL0__B_4 BL0__B_5 BL0__B_6 BL0__B_7 BL1_A_4
+  BL1_A_5 BL1_A_6 BL1_A_7 BL1_B_4 BL1_B_5 BL1_B_6 BL1_B_7 BL1__A_4 BL1__A_5
+  BL1__A_6 BL1__A_7 BL1__B_4 BL1__B_5 BL1__B_6 BL1__B_7 BL2_A_4 BL2_A_5
+  BL2_A_6 BL2_A_7 BL2_B_4 BL2_B_5 BL2_B_6 BL2_B_7 BL2__A_4 BL2__A_5 BL2__A_6
+  BL2__A_7 BL2__B_4 BL2__B_5 BL2__B_6 BL2__B_7 BL3_A_4 BL3_A_5 BL3_A_6
+  BL3_A_7 BL3_B_4 BL3_B_5 BL3_B_6 BL3_B_7 BL3__A_4 BL3__A_5 BL3__A_6 BL3__A_7
+  BL3__B_4 BL3__B_5 BL3__B_6 BL3__B_7 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_4 GDL0_5 GDL0_6 GDL0_7 GDL1_4
+  GDL1_5 GDL1_6 GDL1_7 GDL2_4 GDL2_5 GDL2_6 GDL2_7 GDL3_4 GDL3_5 GDL3_6
+  GDL3_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 SAEN_A SAEN_B TIELO
+  YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI2_0 BL0_A_8 BL0_A_9 BL0_A_10 BL0_A_11 BL0_B_8 BL0_B_9 BL0_B_10 BL0_B_11
+  BL0__A_8 BL0__A_9 BL0__A_10 BL0__A_11 BL0__B_8 BL0__B_9 BL0__B_10 BL0__B_11
+  BL1_A_8 BL1_A_9 BL1_A_10 BL1_A_11 BL1_B_8 BL1_B_9 BL1_B_10 BL1_B_11
+  BL1__A_8 BL1__A_9 BL1__A_10 BL1__A_11 BL1__B_8 BL1__B_9 BL1__B_10 BL1__B_11
+  BL2_A_8 BL2_A_9 BL2_A_10 BL2_A_11 BL2_B_8 BL2_B_9 BL2_B_10 BL2_B_11
+  BL2__A_8 BL2__A_9 BL2__A_10 BL2__A_11 BL2__B_8 BL2__B_9 BL2__B_10 BL2__B_11
+  BL3_A_8 BL3_A_9 BL3_A_10 BL3_A_11 BL3_B_8 BL3_B_9 BL3_B_10 BL3_B_11
+  BL3__A_8 BL3__A_9 BL3__A_10 BL3__A_11 BL3__B_8 BL3__B_9 BL3__B_10 BL3__B_11
+  BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B
+  GDL0_8 GDL0_9 GDL0_10 GDL0_11 GDL1_8 GDL1_9 GDL1_10 GDL1_11 GDL2_8 GDL2_9
+  GDL2_10 GDL2_11 GDL3_8 GDL3_9 GDL3_10 GDL3_11 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21
+  GDL__22 GDL__23 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN
+  YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMUX_COL_HF
XI3_0 BL0_A_12 BL0_A_13 BL0_A_14 BL0_A_15 BL0_B_12 BL0_B_13 BL0_B_14 BL0_B_15
+  BL0__A_12 BL0__A_13 BL0__A_14 BL0__A_15 BL0__B_12 BL0__B_13 BL0__B_14
+  BL0__B_15 BL1_A_12 BL1_A_13 BL1_A_14 BL1_A_15 BL1_B_12 BL1_B_13 BL1_B_14
+  BL1_B_15 BL1__A_12 BL1__A_13 BL1__A_14 BL1__A_15 BL1__B_12 BL1__B_13
+  BL1__B_14 BL1__B_15 BL2_A_12 BL2_A_13 BL2_A_14 BL2_A_15 BL2_B_12 BL2_B_13
+  BL2_B_14 BL2_B_15 BL2__A_12 BL2__A_13 BL2__A_14 BL2__A_15 BL2__B_12
+  BL2__B_13 BL2__B_14 BL2__B_15 BL3_A_12 BL3_A_13 BL3_A_14 BL3_A_15 BL3_B_12
+  BL3_B_13 BL3_B_14 BL3_B_15 BL3__A_12 BL3__A_13 BL3__A_14 BL3__A_15
+  BL3__B_12 BL3__B_13 BL3__B_14 BL3__B_15 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_12 GDL0_13 GDL0_14
+  GDL0_15 GDL1_12 GDL1_13 GDL1_14 GDL1_15 GDL2_12 GDL2_13 GDL2_14 GDL2_15
+  GDL3_12 GDL3_13 GDL3_14 GDL3_15 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30
+  GDL__31 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI4_0 BL0_A_16 BL0_A_17 BL0_A_18 BL0_A_19 BL0_B_16 BL0_B_17 BL0_B_18 BL0_B_19
+  BL0__A_16 BL0__A_17 BL0__A_18 BL0__A_19 BL0__B_16 BL0__B_17 BL0__B_18
+  BL0__B_19 BL1_A_16 BL1_A_17 BL1_A_18 BL1_A_19 BL1_B_16 BL1_B_17 BL1_B_18
+  BL1_B_19 BL1__A_16 BL1__A_17 BL1__A_18 BL1__A_19 BL1__B_16 BL1__B_17
+  BL1__B_18 BL1__B_19 BL2_A_16 BL2_A_17 BL2_A_18 BL2_A_19 BL2_B_16 BL2_B_17
+  BL2_B_18 BL2_B_19 BL2__A_16 BL2__A_17 BL2__A_18 BL2__A_19 BL2__B_16
+  BL2__B_17 BL2__B_18 BL2__B_19 BL3_A_16 BL3_A_17 BL3_A_18 BL3_A_19 BL3_B_16
+  BL3_B_17 BL3_B_18 BL3_B_19 BL3__A_16 BL3__A_17 BL3__A_18 BL3__A_19
+  BL3__B_16 BL3__B_17 BL3__B_18 BL3__B_19 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_16 GDL0_17 GDL0_18
+  GDL0_19 GDL1_16 GDL1_17 GDL1_18 GDL1_19 GDL2_16 GDL2_17 GDL2_18 GDL2_19
+  GDL3_16 GDL3_17 GDL3_18 GDL3_19 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37
+  GDL_38 GDL_39 GDL__32 GDL__33 GDL__34 GDL__35 GDL__36 GDL__37 GDL__38
+  GDL__39 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI5_0 BL0_A_20 BL0_A_21 BL0_A_22 BL0_A_23 BL0_B_20 BL0_B_21 BL0_B_22 BL0_B_23
+  BL0__A_20 BL0__A_21 BL0__A_22 BL0__A_23 BL0__B_20 BL0__B_21 BL0__B_22
+  BL0__B_23 BL1_A_20 BL1_A_21 BL1_A_22 BL1_A_23 BL1_B_20 BL1_B_21 BL1_B_22
+  BL1_B_23 BL1__A_20 BL1__A_21 BL1__A_22 BL1__A_23 BL1__B_20 BL1__B_21
+  BL1__B_22 BL1__B_23 BL2_A_20 BL2_A_21 BL2_A_22 BL2_A_23 BL2_B_20 BL2_B_21
+  BL2_B_22 BL2_B_23 BL2__A_20 BL2__A_21 BL2__A_22 BL2__A_23 BL2__B_20
+  BL2__B_21 BL2__B_22 BL2__B_23 BL3_A_20 BL3_A_21 BL3_A_22 BL3_A_23 BL3_B_20
+  BL3_B_21 BL3_B_22 BL3_B_23 BL3__A_20 BL3__A_21 BL3__A_22 BL3__A_23
+  BL3__B_20 BL3__B_21 BL3__B_22 BL3__B_23 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_20 GDL0_21 GDL0_22
+  GDL0_23 GDL1_20 GDL1_21 GDL1_22 GDL1_23 GDL2_20 GDL2_21 GDL2_22 GDL2_23
+  GDL3_20 GDL3_21 GDL3_22 GDL3_23 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 GDL__40 GDL__41 GDL__42 GDL__43 GDL__44 GDL__45 GDL__46
+  GDL__47 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI6_0 BL0_A_24 BL0_A_25 BL0_A_26 BL0_A_27 BL0_B_24 BL0_B_25 BL0_B_26 BL0_B_27
+  BL0__A_24 BL0__A_25 BL0__A_26 BL0__A_27 BL0__B_24 BL0__B_25 BL0__B_26
+  BL0__B_27 BL1_A_24 BL1_A_25 BL1_A_26 BL1_A_27 BL1_B_24 BL1_B_25 BL1_B_26
+  BL1_B_27 BL1__A_24 BL1__A_25 BL1__A_26 BL1__A_27 BL1__B_24 BL1__B_25
+  BL1__B_26 BL1__B_27 BL2_A_24 BL2_A_25 BL2_A_26 BL2_A_27 BL2_B_24 BL2_B_25
+  BL2_B_26 BL2_B_27 BL2__A_24 BL2__A_25 BL2__A_26 BL2__A_27 BL2__B_24
+  BL2__B_25 BL2__B_26 BL2__B_27 BL3_A_24 BL3_A_25 BL3_A_26 BL3_A_27 BL3_B_24
+  BL3_B_25 BL3_B_26 BL3_B_27 BL3__A_24 BL3__A_25 BL3__A_26 BL3__A_27
+  BL3__B_24 BL3__B_25 BL3__B_26 BL3__B_27 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_24 GDL0_25 GDL0_26
+  GDL0_27 GDL1_24 GDL1_25 GDL1_26 GDL1_27 GDL2_24 GDL2_25 GDL2_26 GDL2_27
+  GDL3_24 GDL3_25 GDL3_26 GDL3_27 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53
+  GDL_54 GDL_55 GDL__48 GDL__49 GDL__50 GDL__51 GDL__52 GDL__53 GDL__54
+  GDL__55 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI7_0 BL0_A_28 BL0_A_29 BL0_A_30 BL0_A_31 BL0_B_28 BL0_B_29 BL0_B_30 BL0_B_31
+  BL0__A_28 BL0__A_29 BL0__A_30 BL0__A_31 BL0__B_28 BL0__B_29 BL0__B_30
+  BL0__B_31 BL1_A_28 BL1_A_29 BL1_A_30 BL1_A_31 BL1_B_28 BL1_B_29 BL1_B_30
+  BL1_B_31 BL1__A_28 BL1__A_29 BL1__A_30 BL1__A_31 BL1__B_28 BL1__B_29
+  BL1__B_30 BL1__B_31 BL2_A_28 BL2_A_29 BL2_A_30 BL2_A_31 BL2_B_28 BL2_B_29
+  BL2_B_30 BL2_B_31 BL2__A_28 BL2__A_29 BL2__A_30 BL2__A_31 BL2__B_28
+  BL2__B_29 BL2__B_30 BL2__B_31 BL3_A_28 BL3_A_29 BL3_A_30 BL3_A_31 BL3_B_28
+  BL3_B_29 BL3_B_30 BL3_B_31 BL3__A_28 BL3__A_29 BL3__A_30 BL3__A_31
+  BL3__B_28 BL3__B_29 BL3__B_30 BL3__B_31 BTPSA_A BTPSA_B BTPT_A BTPT_B
+  BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_28 GDL0_29 GDL0_30
+  GDL0_31 GDL1_28 GDL1_29 GDL1_30 GDL1_31 GDL2_28 GDL2_29 GDL2_30 GDL2_31
+  GDL3_28 GDL3_29 GDL3_30 GDL3_31 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61
+  GDL_62 GDL_63 GDL__56 GDL__57 GDL__58 GDL__59 GDL__60 GDL__61 GDL__62
+  GDL__63 SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpMUX_COL_HF
XI8_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A BTPWN_B BTP_A BTP_B DRPREN_A
+  DRPREN_B SAEN_A SAEN_B TIELO YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN
+  YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpCD_EDGE_HF
.ENDS pe_spad_1024x16_dpMUXCOL_ROW_HF_R
****
.SUBCKT pe_spad_1024x16_dpCHANNEL_0 AX0TRACK_0 AX0TRACK_1 AX1TRACK_0
+  AX1TRACK_1 AX2TRACK_0 AX2TRACK_1 AX3TRACK_0 AX3TRACK_1 AX4TRACK_0
+  AX4TRACK_1 AX5TRACK_0 AX5TRACK_1 AY0TRACK_0 AY0TRACK_1 AY1TRACK_0
+  AY1TRACK_1 BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3 BL0_A_4 BL0_A_5 BL0_A_6 BL0_A_7
+  BL0_A_8 BL0_A_9 BL0_A_10 BL0_A_11 BL0_A_12 BL0_A_13 BL0_A_14 BL0_A_15
+  BL0_A_16 BL0_A_17 BL0_A_18 BL0_A_19 BL0_A_20 BL0_A_21 BL0_A_22 BL0_A_23
+  BL0_A_24 BL0_A_25 BL0_A_26 BL0_A_27 BL0_A_28 BL0_A_29 BL0_A_30 BL0_A_31
+  BL0_A_32 BL0_A_33 BL0_A_34 BL0_A_35 BL0_A_36 BL0_A_37 BL0_A_38 BL0_A_39
+  BL0_A_40 BL0_A_41 BL0_A_42 BL0_A_43 BL0_A_44 BL0_A_45 BL0_A_46 BL0_A_47
+  BL0_A_48 BL0_A_49 BL0_A_50 BL0_A_51 BL0_A_52 BL0_A_53 BL0_A_54 BL0_A_55
+  BL0_A_56 BL0_A_57 BL0_A_58 BL0_A_59 BL0_A_60 BL0_A_61 BL0_A_62 BL0_A_63
+  BL0_B_0 BL0_B_1 BL0_B_2 BL0_B_3 BL0_B_4 BL0_B_5 BL0_B_6 BL0_B_7 BL0_B_8
+  BL0_B_9 BL0_B_10 BL0_B_11 BL0_B_12 BL0_B_13 BL0_B_14 BL0_B_15 BL0_B_16
+  BL0_B_17 BL0_B_18 BL0_B_19 BL0_B_20 BL0_B_21 BL0_B_22 BL0_B_23 BL0_B_24
+  BL0_B_25 BL0_B_26 BL0_B_27 BL0_B_28 BL0_B_29 BL0_B_30 BL0_B_31 BL0_B_32
+  BL0_B_33 BL0_B_34 BL0_B_35 BL0_B_36 BL0_B_37 BL0_B_38 BL0_B_39 BL0_B_40
+  BL0_B_41 BL0_B_42 BL0_B_43 BL0_B_44 BL0_B_45 BL0_B_46 BL0_B_47 BL0_B_48
+  BL0_B_49 BL0_B_50 BL0_B_51 BL0_B_52 BL0_B_53 BL0_B_54 BL0_B_55 BL0_B_56
+  BL0_B_57 BL0_B_58 BL0_B_59 BL0_B_60 BL0_B_61 BL0_B_62 BL0_B_63 BL0__A_0
+  BL0__A_1 BL0__A_2 BL0__A_3 BL0__A_4 BL0__A_5 BL0__A_6 BL0__A_7 BL0__A_8
+  BL0__A_9 BL0__A_10 BL0__A_11 BL0__A_12 BL0__A_13 BL0__A_14 BL0__A_15
+  BL0__A_16 BL0__A_17 BL0__A_18 BL0__A_19 BL0__A_20 BL0__A_21 BL0__A_22
+  BL0__A_23 BL0__A_24 BL0__A_25 BL0__A_26 BL0__A_27 BL0__A_28 BL0__A_29
+  BL0__A_30 BL0__A_31 BL0__A_32 BL0__A_33 BL0__A_34 BL0__A_35 BL0__A_36
+  BL0__A_37 BL0__A_38 BL0__A_39 BL0__A_40 BL0__A_41 BL0__A_42 BL0__A_43
+  BL0__A_44 BL0__A_45 BL0__A_46 BL0__A_47 BL0__A_48 BL0__A_49 BL0__A_50
+  BL0__A_51 BL0__A_52 BL0__A_53 BL0__A_54 BL0__A_55 BL0__A_56 BL0__A_57
+  BL0__A_58 BL0__A_59 BL0__A_60 BL0__A_61 BL0__A_62 BL0__A_63 BL0__B_0
+  BL0__B_1 BL0__B_2 BL0__B_3 BL0__B_4 BL0__B_5 BL0__B_6 BL0__B_7 BL0__B_8
+  BL0__B_9 BL0__B_10 BL0__B_11 BL0__B_12 BL0__B_13 BL0__B_14 BL0__B_15
+  BL0__B_16 BL0__B_17 BL0__B_18 BL0__B_19 BL0__B_20 BL0__B_21 BL0__B_22
+  BL0__B_23 BL0__B_24 BL0__B_25 BL0__B_26 BL0__B_27 BL0__B_28 BL0__B_29
+  BL0__B_30 BL0__B_31 BL0__B_32 BL0__B_33 BL0__B_34 BL0__B_35 BL0__B_36
+  BL0__B_37 BL0__B_38 BL0__B_39 BL0__B_40 BL0__B_41 BL0__B_42 BL0__B_43
+  BL0__B_44 BL0__B_45 BL0__B_46 BL0__B_47 BL0__B_48 BL0__B_49 BL0__B_50
+  BL0__B_51 BL0__B_52 BL0__B_53 BL0__B_54 BL0__B_55 BL0__B_56 BL0__B_57
+  BL0__B_58 BL0__B_59 BL0__B_60 BL0__B_61 BL0__B_62 BL0__B_63 BL1_A_0 BL1_A_1
+  BL1_A_2 BL1_A_3 BL1_A_4 BL1_A_5 BL1_A_6 BL1_A_7 BL1_A_8 BL1_A_9 BL1_A_10
+  BL1_A_11 BL1_A_12 BL1_A_13 BL1_A_14 BL1_A_15 BL1_A_16 BL1_A_17 BL1_A_18
+  BL1_A_19 BL1_A_20 BL1_A_21 BL1_A_22 BL1_A_23 BL1_A_24 BL1_A_25 BL1_A_26
+  BL1_A_27 BL1_A_28 BL1_A_29 BL1_A_30 BL1_A_31 BL1_A_32 BL1_A_33 BL1_A_34
+  BL1_A_35 BL1_A_36 BL1_A_37 BL1_A_38 BL1_A_39 BL1_A_40 BL1_A_41 BL1_A_42
+  BL1_A_43 BL1_A_44 BL1_A_45 BL1_A_46 BL1_A_47 BL1_A_48 BL1_A_49 BL1_A_50
+  BL1_A_51 BL1_A_52 BL1_A_53 BL1_A_54 BL1_A_55 BL1_A_56 BL1_A_57 BL1_A_58
+  BL1_A_59 BL1_A_60 BL1_A_61 BL1_A_62 BL1_A_63 BL1_B_0 BL1_B_1 BL1_B_2
+  BL1_B_3 BL1_B_4 BL1_B_5 BL1_B_6 BL1_B_7 BL1_B_8 BL1_B_9 BL1_B_10 BL1_B_11
+  BL1_B_12 BL1_B_13 BL1_B_14 BL1_B_15 BL1_B_16 BL1_B_17 BL1_B_18 BL1_B_19
+  BL1_B_20 BL1_B_21 BL1_B_22 BL1_B_23 BL1_B_24 BL1_B_25 BL1_B_26 BL1_B_27
+  BL1_B_28 BL1_B_29 BL1_B_30 BL1_B_31 BL1_B_32 BL1_B_33 BL1_B_34 BL1_B_35
+  BL1_B_36 BL1_B_37 BL1_B_38 BL1_B_39 BL1_B_40 BL1_B_41 BL1_B_42 BL1_B_43
+  BL1_B_44 BL1_B_45 BL1_B_46 BL1_B_47 BL1_B_48 BL1_B_49 BL1_B_50 BL1_B_51
+  BL1_B_52 BL1_B_53 BL1_B_54 BL1_B_55 BL1_B_56 BL1_B_57 BL1_B_58 BL1_B_59
+  BL1_B_60 BL1_B_61 BL1_B_62 BL1_B_63 BL1__A_0 BL1__A_1 BL1__A_2 BL1__A_3
+  BL1__A_4 BL1__A_5 BL1__A_6 BL1__A_7 BL1__A_8 BL1__A_9 BL1__A_10 BL1__A_11
+  BL1__A_12 BL1__A_13 BL1__A_14 BL1__A_15 BL1__A_16 BL1__A_17 BL1__A_18
+  BL1__A_19 BL1__A_20 BL1__A_21 BL1__A_22 BL1__A_23 BL1__A_24 BL1__A_25
+  BL1__A_26 BL1__A_27 BL1__A_28 BL1__A_29 BL1__A_30 BL1__A_31 BL1__A_32
+  BL1__A_33 BL1__A_34 BL1__A_35 BL1__A_36 BL1__A_37 BL1__A_38 BL1__A_39
+  BL1__A_40 BL1__A_41 BL1__A_42 BL1__A_43 BL1__A_44 BL1__A_45 BL1__A_46
+  BL1__A_47 BL1__A_48 BL1__A_49 BL1__A_50 BL1__A_51 BL1__A_52 BL1__A_53
+  BL1__A_54 BL1__A_55 BL1__A_56 BL1__A_57 BL1__A_58 BL1__A_59 BL1__A_60
+  BL1__A_61 BL1__A_62 BL1__A_63 BL1__B_0 BL1__B_1 BL1__B_2 BL1__B_3 BL1__B_4
+  BL1__B_5 BL1__B_6 BL1__B_7 BL1__B_8 BL1__B_9 BL1__B_10 BL1__B_11 BL1__B_12
+  BL1__B_13 BL1__B_14 BL1__B_15 BL1__B_16 BL1__B_17 BL1__B_18 BL1__B_19
+  BL1__B_20 BL1__B_21 BL1__B_22 BL1__B_23 BL1__B_24 BL1__B_25 BL1__B_26
+  BL1__B_27 BL1__B_28 BL1__B_29 BL1__B_30 BL1__B_31 BL1__B_32 BL1__B_33
+  BL1__B_34 BL1__B_35 BL1__B_36 BL1__B_37 BL1__B_38 BL1__B_39 BL1__B_40
+  BL1__B_41 BL1__B_42 BL1__B_43 BL1__B_44 BL1__B_45 BL1__B_46 BL1__B_47
+  BL1__B_48 BL1__B_49 BL1__B_50 BL1__B_51 BL1__B_52 BL1__B_53 BL1__B_54
+  BL1__B_55 BL1__B_56 BL1__B_57 BL1__B_58 BL1__B_59 BL1__B_60 BL1__B_61
+  BL1__B_62 BL1__B_63 BL2_A_0 BL2_A_1 BL2_A_2 BL2_A_3 BL2_A_4 BL2_A_5 BL2_A_6
+  BL2_A_7 BL2_A_8 BL2_A_9 BL2_A_10 BL2_A_11 BL2_A_12 BL2_A_13 BL2_A_14
+  BL2_A_15 BL2_A_16 BL2_A_17 BL2_A_18 BL2_A_19 BL2_A_20 BL2_A_21 BL2_A_22
+  BL2_A_23 BL2_A_24 BL2_A_25 BL2_A_26 BL2_A_27 BL2_A_28 BL2_A_29 BL2_A_30
+  BL2_A_31 BL2_A_32 BL2_A_33 BL2_A_34 BL2_A_35 BL2_A_36 BL2_A_37 BL2_A_38
+  BL2_A_39 BL2_A_40 BL2_A_41 BL2_A_42 BL2_A_43 BL2_A_44 BL2_A_45 BL2_A_46
+  BL2_A_47 BL2_A_48 BL2_A_49 BL2_A_50 BL2_A_51 BL2_A_52 BL2_A_53 BL2_A_54
+  BL2_A_55 BL2_A_56 BL2_A_57 BL2_A_58 BL2_A_59 BL2_A_60 BL2_A_61 BL2_A_62
+  BL2_A_63 BL2_B_0 BL2_B_1 BL2_B_2 BL2_B_3 BL2_B_4 BL2_B_5 BL2_B_6 BL2_B_7
+  BL2_B_8 BL2_B_9 BL2_B_10 BL2_B_11 BL2_B_12 BL2_B_13 BL2_B_14 BL2_B_15
+  BL2_B_16 BL2_B_17 BL2_B_18 BL2_B_19 BL2_B_20 BL2_B_21 BL2_B_22 BL2_B_23
+  BL2_B_24 BL2_B_25 BL2_B_26 BL2_B_27 BL2_B_28 BL2_B_29 BL2_B_30 BL2_B_31
+  BL2_B_32 BL2_B_33 BL2_B_34 BL2_B_35 BL2_B_36 BL2_B_37 BL2_B_38 BL2_B_39
+  BL2_B_40 BL2_B_41 BL2_B_42 BL2_B_43 BL2_B_44 BL2_B_45 BL2_B_46 BL2_B_47
+  BL2_B_48 BL2_B_49 BL2_B_50 BL2_B_51 BL2_B_52 BL2_B_53 BL2_B_54 BL2_B_55
+  BL2_B_56 BL2_B_57 BL2_B_58 BL2_B_59 BL2_B_60 BL2_B_61 BL2_B_62 BL2_B_63
+  BL2__A_0 BL2__A_1 BL2__A_2 BL2__A_3 BL2__A_4 BL2__A_5 BL2__A_6 BL2__A_7
+  BL2__A_8 BL2__A_9 BL2__A_10 BL2__A_11 BL2__A_12 BL2__A_13 BL2__A_14
+  BL2__A_15 BL2__A_16 BL2__A_17 BL2__A_18 BL2__A_19 BL2__A_20 BL2__A_21
+  BL2__A_22 BL2__A_23 BL2__A_24 BL2__A_25 BL2__A_26 BL2__A_27 BL2__A_28
+  BL2__A_29 BL2__A_30 BL2__A_31 BL2__A_32 BL2__A_33 BL2__A_34 BL2__A_35
+  BL2__A_36 BL2__A_37 BL2__A_38 BL2__A_39 BL2__A_40 BL2__A_41 BL2__A_42
+  BL2__A_43 BL2__A_44 BL2__A_45 BL2__A_46 BL2__A_47 BL2__A_48 BL2__A_49
+  BL2__A_50 BL2__A_51 BL2__A_52 BL2__A_53 BL2__A_54 BL2__A_55 BL2__A_56
+  BL2__A_57 BL2__A_58 BL2__A_59 BL2__A_60 BL2__A_61 BL2__A_62 BL2__A_63
+  BL2__B_0 BL2__B_1 BL2__B_2 BL2__B_3 BL2__B_4 BL2__B_5 BL2__B_6 BL2__B_7
+  BL2__B_8 BL2__B_9 BL2__B_10 BL2__B_11 BL2__B_12 BL2__B_13 BL2__B_14
+  BL2__B_15 BL2__B_16 BL2__B_17 BL2__B_18 BL2__B_19 BL2__B_20 BL2__B_21
+  BL2__B_22 BL2__B_23 BL2__B_24 BL2__B_25 BL2__B_26 BL2__B_27 BL2__B_28
+  BL2__B_29 BL2__B_30 BL2__B_31 BL2__B_32 BL2__B_33 BL2__B_34 BL2__B_35
+  BL2__B_36 BL2__B_37 BL2__B_38 BL2__B_39 BL2__B_40 BL2__B_41 BL2__B_42
+  BL2__B_43 BL2__B_44 BL2__B_45 BL2__B_46 BL2__B_47 BL2__B_48 BL2__B_49
+  BL2__B_50 BL2__B_51 BL2__B_52 BL2__B_53 BL2__B_54 BL2__B_55 BL2__B_56
+  BL2__B_57 BL2__B_58 BL2__B_59 BL2__B_60 BL2__B_61 BL2__B_62 BL2__B_63
+  BL3_A_0 BL3_A_1 BL3_A_2 BL3_A_3 BL3_A_4 BL3_A_5 BL3_A_6 BL3_A_7 BL3_A_8
+  BL3_A_9 BL3_A_10 BL3_A_11 BL3_A_12 BL3_A_13 BL3_A_14 BL3_A_15 BL3_A_16
+  BL3_A_17 BL3_A_18 BL3_A_19 BL3_A_20 BL3_A_21 BL3_A_22 BL3_A_23 BL3_A_24
+  BL3_A_25 BL3_A_26 BL3_A_27 BL3_A_28 BL3_A_29 BL3_A_30 BL3_A_31 BL3_A_32
+  BL3_A_33 BL3_A_34 BL3_A_35 BL3_A_36 BL3_A_37 BL3_A_38 BL3_A_39 BL3_A_40
+  BL3_A_41 BL3_A_42 BL3_A_43 BL3_A_44 BL3_A_45 BL3_A_46 BL3_A_47 BL3_A_48
+  BL3_A_49 BL3_A_50 BL3_A_51 BL3_A_52 BL3_A_53 BL3_A_54 BL3_A_55 BL3_A_56
+  BL3_A_57 BL3_A_58 BL3_A_59 BL3_A_60 BL3_A_61 BL3_A_62 BL3_A_63 BL3_B_0
+  BL3_B_1 BL3_B_2 BL3_B_3 BL3_B_4 BL3_B_5 BL3_B_6 BL3_B_7 BL3_B_8 BL3_B_9
+  BL3_B_10 BL3_B_11 BL3_B_12 BL3_B_13 BL3_B_14 BL3_B_15 BL3_B_16 BL3_B_17
+  BL3_B_18 BL3_B_19 BL3_B_20 BL3_B_21 BL3_B_22 BL3_B_23 BL3_B_24 BL3_B_25
+  BL3_B_26 BL3_B_27 BL3_B_28 BL3_B_29 BL3_B_30 BL3_B_31 BL3_B_32 BL3_B_33
+  BL3_B_34 BL3_B_35 BL3_B_36 BL3_B_37 BL3_B_38 BL3_B_39 BL3_B_40 BL3_B_41
+  BL3_B_42 BL3_B_43 BL3_B_44 BL3_B_45 BL3_B_46 BL3_B_47 BL3_B_48 BL3_B_49
+  BL3_B_50 BL3_B_51 BL3_B_52 BL3_B_53 BL3_B_54 BL3_B_55 BL3_B_56 BL3_B_57
+  BL3_B_58 BL3_B_59 BL3_B_60 BL3_B_61 BL3_B_62 BL3_B_63 BL3__A_0 BL3__A_1
+  BL3__A_2 BL3__A_3 BL3__A_4 BL3__A_5 BL3__A_6 BL3__A_7 BL3__A_8 BL3__A_9
+  BL3__A_10 BL3__A_11 BL3__A_12 BL3__A_13 BL3__A_14 BL3__A_15 BL3__A_16
+  BL3__A_17 BL3__A_18 BL3__A_19 BL3__A_20 BL3__A_21 BL3__A_22 BL3__A_23
+  BL3__A_24 BL3__A_25 BL3__A_26 BL3__A_27 BL3__A_28 BL3__A_29 BL3__A_30
+  BL3__A_31 BL3__A_32 BL3__A_33 BL3__A_34 BL3__A_35 BL3__A_36 BL3__A_37
+  BL3__A_38 BL3__A_39 BL3__A_40 BL3__A_41 BL3__A_42 BL3__A_43 BL3__A_44
+  BL3__A_45 BL3__A_46 BL3__A_47 BL3__A_48 BL3__A_49 BL3__A_50 BL3__A_51
+  BL3__A_52 BL3__A_53 BL3__A_54 BL3__A_55 BL3__A_56 BL3__A_57 BL3__A_58
+  BL3__A_59 BL3__A_60 BL3__A_61 BL3__A_62 BL3__A_63 BL3__B_0 BL3__B_1
+  BL3__B_2 BL3__B_3 BL3__B_4 BL3__B_5 BL3__B_6 BL3__B_7 BL3__B_8 BL3__B_9
+  BL3__B_10 BL3__B_11 BL3__B_12 BL3__B_13 BL3__B_14 BL3__B_15 BL3__B_16
+  BL3__B_17 BL3__B_18 BL3__B_19 BL3__B_20 BL3__B_21 BL3__B_22 BL3__B_23
+  BL3__B_24 BL3__B_25 BL3__B_26 BL3__B_27 BL3__B_28 BL3__B_29 BL3__B_30
+  BL3__B_31 BL3__B_32 BL3__B_33 BL3__B_34 BL3__B_35 BL3__B_36 BL3__B_37
+  BL3__B_38 BL3__B_39 BL3__B_40 BL3__B_41 BL3__B_42 BL3__B_43 BL3__B_44
+  BL3__B_45 BL3__B_46 BL3__B_47 BL3__B_48 BL3__B_49 BL3__B_50 BL3__B_51
+  BL3__B_52 BL3__B_53 BL3__B_54 BL3__B_55 BL3__B_56 BL3__B_57 BL3__B_58
+  BL3__B_59 BL3__B_60 BL3__B_61 BL3__B_62 BL3__B_63 BS0NT_0 BS0NT_1 BS0N_0
+  BS0N_1 BS1NT_0 BS1NT_1 BS1N_0 BS1N_1 BS2NT_0 BS2NT_1 BS2N_0 BS2N_1 BTPWDT_0
+  BTPWDT_1 GDL0_0 GDL0_1 GDL0_2 GDL0_3 GDL0_4 GDL0_5 GDL0_6 GDL0_7 GDL0_8
+  GDL0_9 GDL0_10 GDL0_11 GDL0_12 GDL0_13 GDL0_14 GDL0_15 GDL0_16 GDL0_17
+  GDL0_18 GDL0_19 GDL0_20 GDL0_21 GDL0_22 GDL0_23 GDL0_24 GDL0_25 GDL0_26
+  GDL0_27 GDL0_28 GDL0_29 GDL0_30 GDL0_31 GDL0_32 GDL0_33 GDL0_34 GDL0_35
+  GDL0_36 GDL0_37 GDL0_38 GDL0_39 GDL0_40 GDL0_41 GDL0_42 GDL0_43 GDL0_44
+  GDL0_45 GDL0_46 GDL0_47 GDL0_48 GDL0_49 GDL0_50 GDL0_51 GDL0_52 GDL0_53
+  GDL0_54 GDL0_55 GDL0_56 GDL0_57 GDL0_58 GDL0_59 GDL0_60 GDL0_61 GDL0_62
+  GDL0_63 GDL1_0 GDL1_1 GDL1_2 GDL1_3 GDL1_4 GDL1_5 GDL1_6 GDL1_7 GDL1_8
+  GDL1_9 GDL1_10 GDL1_11 GDL1_12 GDL1_13 GDL1_14 GDL1_15 GDL1_16 GDL1_17
+  GDL1_18 GDL1_19 GDL1_20 GDL1_21 GDL1_22 GDL1_23 GDL1_24 GDL1_25 GDL1_26
+  GDL1_27 GDL1_28 GDL1_29 GDL1_30 GDL1_31 GDL1_32 GDL1_33 GDL1_34 GDL1_35
+  GDL1_36 GDL1_37 GDL1_38 GDL1_39 GDL1_40 GDL1_41 GDL1_42 GDL1_43 GDL1_44
+  GDL1_45 GDL1_46 GDL1_47 GDL1_48 GDL1_49 GDL1_50 GDL1_51 GDL1_52 GDL1_53
+  GDL1_54 GDL1_55 GDL1_56 GDL1_57 GDL1_58 GDL1_59 GDL1_60 GDL1_61 GDL1_62
+  GDL1_63 GDL2_0 GDL2_1 GDL2_2 GDL2_3 GDL2_4 GDL2_5 GDL2_6 GDL2_7 GDL2_8
+  GDL2_9 GDL2_10 GDL2_11 GDL2_12 GDL2_13 GDL2_14 GDL2_15 GDL2_16 GDL2_17
+  GDL2_18 GDL2_19 GDL2_20 GDL2_21 GDL2_22 GDL2_23 GDL2_24 GDL2_25 GDL2_26
+  GDL2_27 GDL2_28 GDL2_29 GDL2_30 GDL2_31 GDL2_32 GDL2_33 GDL2_34 GDL2_35
+  GDL2_36 GDL2_37 GDL2_38 GDL2_39 GDL2_40 GDL2_41 GDL2_42 GDL2_43 GDL2_44
+  GDL2_45 GDL2_46 GDL2_47 GDL2_48 GDL2_49 GDL2_50 GDL2_51 GDL2_52 GDL2_53
+  GDL2_54 GDL2_55 GDL2_56 GDL2_57 GDL2_58 GDL2_59 GDL2_60 GDL2_61 GDL2_62
+  GDL2_63 GDL3_0 GDL3_1 GDL3_2 GDL3_3 GDL3_4 GDL3_5 GDL3_6 GDL3_7 GDL3_8
+  GDL3_9 GDL3_10 GDL3_11 GDL3_12 GDL3_13 GDL3_14 GDL3_15 GDL3_16 GDL3_17
+  GDL3_18 GDL3_19 GDL3_20 GDL3_21 GDL3_22 GDL3_23 GDL3_24 GDL3_25 GDL3_26
+  GDL3_27 GDL3_28 GDL3_29 GDL3_30 GDL3_31 GDL3_32 GDL3_33 GDL3_34 GDL3_35
+  GDL3_36 GDL3_37 GDL3_38 GDL3_39 GDL3_40 GDL3_41 GDL3_42 GDL3_43 GDL3_44
+  GDL3_45 GDL3_46 GDL3_47 GDL3_48 GDL3_49 GDL3_50 GDL3_51 GDL3_52 GDL3_53
+  GDL3_54 GDL3_55 GDL3_56 GDL3_57 GDL3_58 GDL3_59 GDL3_60 GDL3_61 GDL3_62
+  GDL3_63 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9
+  GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17 GDL__18
+  GDL__19 GDL__20 GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26 GDL__27
+  GDL__28 GDL__29 GDL__30 GDL__31 GDL__32 GDL__33 GDL__34 GDL__35 GDL__36
+  GDL__37 GDL__38 GDL__39 GDL__40 GDL__41 GDL__42 GDL__43 GDL__44 GDL__45
+  GDL__46 GDL__47 GDL__48 GDL__49 GDL__50 GDL__51 GDL__52 GDL__53 GDL__54
+  GDL__55 GDL__56 GDL__57 GDL__58 GDL__59 GDL__60 GDL__61 GDL__62 GDL__63
+  GDL__64 GDL__65 GDL__66 GDL__67 GDL__68 GDL__69 GDL__70 GDL__71 GDL__72
+  GDL__73 GDL__74 GDL__75 GDL__76 GDL__77 GDL__78 GDL__79 GDL__80 GDL__81
+  GDL__82 GDL__83 GDL__84 GDL__85 GDL__86 GDL__87 GDL__88 GDL__89 GDL__90
+  GDL__91 GDL__92 GDL__93 GDL__94 GDL__95 GDL__96 GDL__97 GDL__98 GDL__99
+  GDL__100 GDL__101 GDL__102 GDL__103 GDL__104 GDL__105 GDL__106 GDL__107
+  GDL__108 GDL__109 GDL__110 GDL__111 GDL__112 GDL__113 GDL__114 GDL__115
+  GDL__116 GDL__117 GDL__118 GDL__119 GDL__120 GDL__121 GDL__122 GDL__123
+  GDL__124 GDL__125 GDL__126 GDL__127 GTPDET_0 GTPDET_1 GTPDT_0 GTPDT_1
+  GTPD_0 GTPD_1 GTPT_0 GTPT_1 LGWET_0 LGWET_1 MBL_0 MBL_1 MGDLET_0 MGDLET_1
+  MGDLE_0 MGDLE_1 MGDLST_0 MGDLST_1 MGTPST_0 MGTPST_1 MGTPS_0 MGTPS_1 RBTPT_0
+  RBTPT_1 RDTN_0 RDTN_1 RET_0 RET_1 RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0
+  RRA1_1 RRA1__0 RRA1__1 RRENT_0 RRENT_1 RREN_0 RREN_1 TIEHI_0 TIEHI_1
+  TIELO_0 TIELO_1 WBT_0 WBT_1 XP0_0 XP0_1 XP1_0 XP1_1 XP2_0 XP2_1 XP3_0 XP3_1
+  XP4_0 XP4_1 XP5_0 XP5_1 XP6_0 XP6_1 XP7_0 XP7_1 XP8_0 XP8_1 XP9_0 XP9_1
+  XP10_0 XP10_1 XP11_0 XP11_1 XP12_0 XP12_1 XP13_0 XP13_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCHANNEL_0: 13740 flat devices **
XI0_0 BL0_A_31 BL0_A_30 BL0_A_29 BL0_A_28 BL0_A_27 BL0_A_26 BL0_A_25 BL0_A_24
+  BL0_A_23 BL0_A_22 BL0_A_21 BL0_A_20 BL0_A_19 BL0_A_18 BL0_A_17 BL0_A_16
+  BL0_A_15 BL0_A_14 BL0_A_13 BL0_A_12 BL0_A_11 BL0_A_10 BL0_A_9 BL0_A_8
+  BL0_A_7 BL0_A_6 BL0_A_5 BL0_A_4 BL0_A_3 BL0_A_2 BL0_A_1 BL0_A_0 BL0_B_31
+  BL0_B_30 BL0_B_29 BL0_B_28 BL0_B_27 BL0_B_26 BL0_B_25 BL0_B_24 BL0_B_23
+  BL0_B_22 BL0_B_21 BL0_B_20 BL0_B_19 BL0_B_18 BL0_B_17 BL0_B_16 BL0_B_15
+  BL0_B_14 BL0_B_13 BL0_B_12 BL0_B_11 BL0_B_10 BL0_B_9 BL0_B_8 BL0_B_7
+  BL0_B_6 BL0_B_5 BL0_B_4 BL0_B_3 BL0_B_2 BL0_B_1 BL0_B_0 BL0__A_31 BL0__A_30
+  BL0__A_29 BL0__A_28 BL0__A_27 BL0__A_26 BL0__A_25 BL0__A_24 BL0__A_23
+  BL0__A_22 BL0__A_21 BL0__A_20 BL0__A_19 BL0__A_18 BL0__A_17 BL0__A_16
+  BL0__A_15 BL0__A_14 BL0__A_13 BL0__A_12 BL0__A_11 BL0__A_10 BL0__A_9
+  BL0__A_8 BL0__A_7 BL0__A_6 BL0__A_5 BL0__A_4 BL0__A_3 BL0__A_2 BL0__A_1
+  BL0__A_0 BL0__B_31 BL0__B_30 BL0__B_29 BL0__B_28 BL0__B_27 BL0__B_26
+  BL0__B_25 BL0__B_24 BL0__B_23 BL0__B_22 BL0__B_21 BL0__B_20 BL0__B_19
+  BL0__B_18 BL0__B_17 BL0__B_16 BL0__B_15 BL0__B_14 BL0__B_13 BL0__B_12
+  BL0__B_11 BL0__B_10 BL0__B_9 BL0__B_8 BL0__B_7 BL0__B_6 BL0__B_5 BL0__B_4
+  BL0__B_3 BL0__B_2 BL0__B_1 BL0__B_0 BL1_A_31 BL1_A_30 BL1_A_29 BL1_A_28
+  BL1_A_27 BL1_A_26 BL1_A_25 BL1_A_24 BL1_A_23 BL1_A_22 BL1_A_21 BL1_A_20
+  BL1_A_19 BL1_A_18 BL1_A_17 BL1_A_16 BL1_A_15 BL1_A_14 BL1_A_13 BL1_A_12
+  BL1_A_11 BL1_A_10 BL1_A_9 BL1_A_8 BL1_A_7 BL1_A_6 BL1_A_5 BL1_A_4 BL1_A_3
+  BL1_A_2 BL1_A_1 BL1_A_0 BL1_B_31 BL1_B_30 BL1_B_29 BL1_B_28 BL1_B_27
+  BL1_B_26 BL1_B_25 BL1_B_24 BL1_B_23 BL1_B_22 BL1_B_21 BL1_B_20 BL1_B_19
+  BL1_B_18 BL1_B_17 BL1_B_16 BL1_B_15 BL1_B_14 BL1_B_13 BL1_B_12 BL1_B_11
+  BL1_B_10 BL1_B_9 BL1_B_8 BL1_B_7 BL1_B_6 BL1_B_5 BL1_B_4 BL1_B_3 BL1_B_2
+  BL1_B_1 BL1_B_0 BL1__A_31 BL1__A_30 BL1__A_29 BL1__A_28 BL1__A_27 BL1__A_26
+  BL1__A_25 BL1__A_24 BL1__A_23 BL1__A_22 BL1__A_21 BL1__A_20 BL1__A_19
+  BL1__A_18 BL1__A_17 BL1__A_16 BL1__A_15 BL1__A_14 BL1__A_13 BL1__A_12
+  BL1__A_11 BL1__A_10 BL1__A_9 BL1__A_8 BL1__A_7 BL1__A_6 BL1__A_5 BL1__A_4
+  BL1__A_3 BL1__A_2 BL1__A_1 BL1__A_0 BL1__B_31 BL1__B_30 BL1__B_29 BL1__B_28
+  BL1__B_27 BL1__B_26 BL1__B_25 BL1__B_24 BL1__B_23 BL1__B_22 BL1__B_21
+  BL1__B_20 BL1__B_19 BL1__B_18 BL1__B_17 BL1__B_16 BL1__B_15 BL1__B_14
+  BL1__B_13 BL1__B_12 BL1__B_11 BL1__B_10 BL1__B_9 BL1__B_8 BL1__B_7 BL1__B_6
+  BL1__B_5 BL1__B_4 BL1__B_3 BL1__B_2 BL1__B_1 BL1__B_0 BL2_A_31 BL2_A_30
+  BL2_A_29 BL2_A_28 BL2_A_27 BL2_A_26 BL2_A_25 BL2_A_24 BL2_A_23 BL2_A_22
+  BL2_A_21 BL2_A_20 BL2_A_19 BL2_A_18 BL2_A_17 BL2_A_16 BL2_A_15 BL2_A_14
+  BL2_A_13 BL2_A_12 BL2_A_11 BL2_A_10 BL2_A_9 BL2_A_8 BL2_A_7 BL2_A_6 BL2_A_5
+  BL2_A_4 BL2_A_3 BL2_A_2 BL2_A_1 BL2_A_0 BL2_B_31 BL2_B_30 BL2_B_29 BL2_B_28
+  BL2_B_27 BL2_B_26 BL2_B_25 BL2_B_24 BL2_B_23 BL2_B_22 BL2_B_21 BL2_B_20
+  BL2_B_19 BL2_B_18 BL2_B_17 BL2_B_16 BL2_B_15 BL2_B_14 BL2_B_13 BL2_B_12
+  BL2_B_11 BL2_B_10 BL2_B_9 BL2_B_8 BL2_B_7 BL2_B_6 BL2_B_5 BL2_B_4 BL2_B_3
+  BL2_B_2 BL2_B_1 BL2_B_0 BL2__A_31 BL2__A_30 BL2__A_29 BL2__A_28 BL2__A_27
+  BL2__A_26 BL2__A_25 BL2__A_24 BL2__A_23 BL2__A_22 BL2__A_21 BL2__A_20
+  BL2__A_19 BL2__A_18 BL2__A_17 BL2__A_16 BL2__A_15 BL2__A_14 BL2__A_13
+  BL2__A_12 BL2__A_11 BL2__A_10 BL2__A_9 BL2__A_8 BL2__A_7 BL2__A_6 BL2__A_5
+  BL2__A_4 BL2__A_3 BL2__A_2 BL2__A_1 BL2__A_0 BL2__B_31 BL2__B_30 BL2__B_29
+  BL2__B_28 BL2__B_27 BL2__B_26 BL2__B_25 BL2__B_24 BL2__B_23 BL2__B_22
+  BL2__B_21 BL2__B_20 BL2__B_19 BL2__B_18 BL2__B_17 BL2__B_16 BL2__B_15
+  BL2__B_14 BL2__B_13 BL2__B_12 BL2__B_11 BL2__B_10 BL2__B_9 BL2__B_8
+  BL2__B_7 BL2__B_6 BL2__B_5 BL2__B_4 BL2__B_3 BL2__B_2 BL2__B_1 BL2__B_0
+  BL3_A_31 BL3_A_30 BL3_A_29 BL3_A_28 BL3_A_27 BL3_A_26 BL3_A_25 BL3_A_24
+  BL3_A_23 BL3_A_22 BL3_A_21 BL3_A_20 BL3_A_19 BL3_A_18 BL3_A_17 BL3_A_16
+  BL3_A_15 BL3_A_14 BL3_A_13 BL3_A_12 BL3_A_11 BL3_A_10 BL3_A_9 BL3_A_8
+  BL3_A_7 BL3_A_6 BL3_A_5 BL3_A_4 BL3_A_3 BL3_A_2 BL3_A_1 BL3_A_0 BL3_B_31
+  BL3_B_30 BL3_B_29 BL3_B_28 BL3_B_27 BL3_B_26 BL3_B_25 BL3_B_24 BL3_B_23
+  BL3_B_22 BL3_B_21 BL3_B_20 BL3_B_19 BL3_B_18 BL3_B_17 BL3_B_16 BL3_B_15
+  BL3_B_14 BL3_B_13 BL3_B_12 BL3_B_11 BL3_B_10 BL3_B_9 BL3_B_8 BL3_B_7
+  BL3_B_6 BL3_B_5 BL3_B_4 BL3_B_3 BL3_B_2 BL3_B_1 BL3_B_0 BL3__A_31 BL3__A_30
+  BL3__A_29 BL3__A_28 BL3__A_27 BL3__A_26 BL3__A_25 BL3__A_24 BL3__A_23
+  BL3__A_22 BL3__A_21 BL3__A_20 BL3__A_19 BL3__A_18 BL3__A_17 BL3__A_16
+  BL3__A_15 BL3__A_14 BL3__A_13 BL3__A_12 BL3__A_11 BL3__A_10 BL3__A_9
+  BL3__A_8 BL3__A_7 BL3__A_6 BL3__A_5 BL3__A_4 BL3__A_3 BL3__A_2 BL3__A_1
+  BL3__A_0 BL3__B_31 BL3__B_30 BL3__B_29 BL3__B_28 BL3__B_27 BL3__B_26
+  BL3__B_25 BL3__B_24 BL3__B_23 BL3__B_22 BL3__B_21 BL3__B_20 BL3__B_19
+  BL3__B_18 BL3__B_17 BL3__B_16 BL3__B_15 BL3__B_14 BL3__B_13 BL3__B_12
+  BL3__B_11 BL3__B_10 BL3__B_9 BL3__B_8 BL3__B_7 BL3__B_6 BL3__B_5 BL3__B_4
+  BL3__B_3 BL3__B_2 BL3__B_1 BL3__B_0 BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWN_A
+  BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GDL0_31 GDL0_30 GDL0_29 GDL0_28
+  GDL0_27 GDL0_26 GDL0_25 GDL0_24 GDL0_23 GDL0_22 GDL0_21 GDL0_20 GDL0_19
+  GDL0_18 GDL0_17 GDL0_16 GDL0_15 GDL0_14 GDL0_13 GDL0_12 GDL0_11 GDL0_10
+  GDL0_9 GDL0_8 GDL0_7 GDL0_6 GDL0_5 GDL0_4 GDL0_3 GDL0_2 GDL0_1 GDL0_0
+  GDL1_31 GDL1_30 GDL1_29 GDL1_28 GDL1_27 GDL1_26 GDL1_25 GDL1_24 GDL1_23
+  GDL1_22 GDL1_21 GDL1_20 GDL1_19 GDL1_18 GDL1_17 GDL1_16 GDL1_15 GDL1_14
+  GDL1_13 GDL1_12 GDL1_11 GDL1_10 GDL1_9 GDL1_8 GDL1_7 GDL1_6 GDL1_5 GDL1_4
+  GDL1_3 GDL1_2 GDL1_1 GDL1_0 GDL2_31 GDL2_30 GDL2_29 GDL2_28 GDL2_27 GDL2_26
+  GDL2_25 GDL2_24 GDL2_23 GDL2_22 GDL2_21 GDL2_20 GDL2_19 GDL2_18 GDL2_17
+  GDL2_16 GDL2_15 GDL2_14 GDL2_13 GDL2_12 GDL2_11 GDL2_10 GDL2_9 GDL2_8
+  GDL2_7 GDL2_6 GDL2_5 GDL2_4 GDL2_3 GDL2_2 GDL2_1 GDL2_0 GDL3_31 GDL3_30
+  GDL3_29 GDL3_28 GDL3_27 GDL3_26 GDL3_25 GDL3_24 GDL3_23 GDL3_22 GDL3_21
+  GDL3_20 GDL3_19 GDL3_18 GDL3_17 GDL3_16 GDL3_15 GDL3_14 GDL3_13 GDL3_12
+  GDL3_11 GDL3_10 GDL3_9 GDL3_8 GDL3_7 GDL3_6 GDL3_5 GDL3_4 GDL3_3 GDL3_2
+  GDL3_1 GDL3_0 GDL_63 GDL_62 GDL_61 GDL_60 GDL_59 GDL_58 GDL_57 GDL_56
+  GDL_55 GDL_54 GDL_53 GDL_52 GDL_51 GDL_50 GDL_49 GDL_48 GDL_47 GDL_46
+  GDL_45 GDL_44 GDL_43 GDL_42 GDL_41 GDL_40 GDL_39 GDL_38 GDL_37 GDL_36
+  GDL_35 GDL_34 GDL_33 GDL_32 GDL_31 GDL_30 GDL_29 GDL_28 GDL_27 GDL_26
+  GDL_25 GDL_24 GDL_23 GDL_22 GDL_21 GDL_20 GDL_19 GDL_18 GDL_17 GDL_16
+  GDL_15 GDL_14 GDL_13 GDL_12 GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5
+  GDL_4 GDL_3 GDL_2 GDL_1 GDL_0 GDL__63 GDL__62 GDL__61 GDL__60 GDL__59
+  GDL__58 GDL__57 GDL__56 GDL__55 GDL__54 GDL__53 GDL__52 GDL__51 GDL__50
+  GDL__49 GDL__48 GDL__47 GDL__46 GDL__45 GDL__44 GDL__43 GDL__42 GDL__41
+  GDL__40 GDL__39 GDL__38 GDL__37 GDL__36 GDL__35 GDL__34 GDL__33 GDL__32
+  GDL__31 GDL__30 GDL__29 GDL__28 GDL__27 GDL__26 GDL__25 GDL__24 GDL__23
+  GDL__22 GDL__21 GDL__20 GDL__19 GDL__18 GDL__17 GDL__16 GDL__15 GDL__14
+  GDL__13 GDL__12 GDL__11 GDL__10 GDL__9 GDL__8 GDL__7 GDL__6 GDL__5 GDL__4
+  GDL__3 GDL__2 GDL__1 GDL__0 SAEN_A SAEN_B TIELO_0 YP0_0_AN YP0_0_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMUXCOL_ROW_HF_L
XI1_0 AX0TRACK_0 AX1TRACK_0 AX2TRACK_0 AX3TRACK_0 AX4TRACK_0 AX5TRACK_0
+  AY0TRACK_0 AY1TRACK_0 BLKSELT_A BLKSELT_B BS0N_0 BS0NT_0 BS1N_0 BS1NT_0
+  BS2N_0 BS2NT_0 SAEN_A SAEN_B BTPSA_A BTPSA_B BTPT_A BTPT_B BTPWDT_0 BTPWN_A
+  BTPWN_B BTP_A BTP_B DRPREN_A DRPREN_B GSAEN_A GSAEN_B GTPCDNT_A GTPCDNT_B
+  GTPD_0 GTPDET_0 GTPDT_0 GTPSANT_A GTPSANT_B GTPSA_A GTPSA_B GTPT_0 GTPWN_A
+  GTPWN_B LGWET_0 MBL_0 MGDLE_0 MGDLET_0 MGDLST_0 MGTPS_0 MGTPST_0 RBTPT_0
+  RDTN_0 RET_0 RRA0_0 RRA0__0 RRA1_0 RRA1__0 RREN_0 RRENT_0 TIEHI_0 TIELO_0
+  WBT_0 XP0_0 XP1_0 XP2_0 XP3_0 XP4_0 XP5_0 XP6_0 XP7_0 XP8_0 XP9_0 XP10_0
+  XP11_0 XP12_0 XP13_0 YP0_0_AN YP0_0_BN YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN
+  YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE pe_spad_1024x16_dpBKCTRL_HF_L_0
XI2_0 AX0TRACK_1 AX1TRACK_1 AX2TRACK_1 AX3TRACK_1 AX4TRACK_1 AX5TRACK_1
+  AY0TRACK_1 AY1TRACK_1 BLKSELT_A BLKSELT_B BS0N_1 BS0NT_1 BS1N_1 BS1NT_1
+  BS2N_1 BS2NT_1 BSAEN_A BSAEN_B BTPSA_A_40 BTPSA_B_42 BTPT_A_36 BTPT_B_38
+  BTPWDT_1 BTPWN_A_46 BTPWN_B_48 BTP_AT BTP_BT DRPREN_AT DRPREN_BT GSAEN_A
+  GSAEN_B GTPCDNT_A GTPCDNT_B GTPD_1 GTPDET_1 GTPDT_1 GTPSANT_A GTPSANT_B
+  GTPSA_A GTPSA_B GTPT_1 GTPWN_A GTPWN_B LGWET_1 MBL_1 MGDLE_1 MGDLET_1
+  MGDLST_1 MGTPS_1 MGTPST_1 RBTPT_1 RDTN_1 RET_1 RRA0_1 RRA0__1 RRA1_1
+  RRA1__1 RREN_1 RRENT_1 TIEHI_1 TIELO_1 WBT_1 XP0_1 XP1_1 XP2_1 XP3_1 XP4_1
+  XP5_1 XP6_1 XP7_1 XP8_1 XP9_1 XP10_1 XP11_1 XP12_1 XP13_1 YP0_0_AN YP0_0_BN
+  YP0_1_AN YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBKCTRL_HF_R_0
XI3_0 BL0_A_32 BL0_A_33 BL0_A_34 BL0_A_35 BL0_A_36 BL0_A_37 BL0_A_38 BL0_A_39
+  BL0_A_40 BL0_A_41 BL0_A_42 BL0_A_43 BL0_A_44 BL0_A_45 BL0_A_46 BL0_A_47
+  BL0_A_48 BL0_A_49 BL0_A_50 BL0_A_51 BL0_A_52 BL0_A_53 BL0_A_54 BL0_A_55
+  BL0_A_56 BL0_A_57 BL0_A_58 BL0_A_59 BL0_A_60 BL0_A_61 BL0_A_62 BL0_A_63
+  BL0_B_32 BL0_B_33 BL0_B_34 BL0_B_35 BL0_B_36 BL0_B_37 BL0_B_38 BL0_B_39
+  BL0_B_40 BL0_B_41 BL0_B_42 BL0_B_43 BL0_B_44 BL0_B_45 BL0_B_46 BL0_B_47
+  BL0_B_48 BL0_B_49 BL0_B_50 BL0_B_51 BL0_B_52 BL0_B_53 BL0_B_54 BL0_B_55
+  BL0_B_56 BL0_B_57 BL0_B_58 BL0_B_59 BL0_B_60 BL0_B_61 BL0_B_62 BL0_B_63
+  BL0__A_32 BL0__A_33 BL0__A_34 BL0__A_35 BL0__A_36 BL0__A_37 BL0__A_38
+  BL0__A_39 BL0__A_40 BL0__A_41 BL0__A_42 BL0__A_43 BL0__A_44 BL0__A_45
+  BL0__A_46 BL0__A_47 BL0__A_48 BL0__A_49 BL0__A_50 BL0__A_51 BL0__A_52
+  BL0__A_53 BL0__A_54 BL0__A_55 BL0__A_56 BL0__A_57 BL0__A_58 BL0__A_59
+  BL0__A_60 BL0__A_61 BL0__A_62 BL0__A_63 BL0__B_32 BL0__B_33 BL0__B_34
+  BL0__B_35 BL0__B_36 BL0__B_37 BL0__B_38 BL0__B_39 BL0__B_40 BL0__B_41
+  BL0__B_42 BL0__B_43 BL0__B_44 BL0__B_45 BL0__B_46 BL0__B_47 BL0__B_48
+  BL0__B_49 BL0__B_50 BL0__B_51 BL0__B_52 BL0__B_53 BL0__B_54 BL0__B_55
+  BL0__B_56 BL0__B_57 BL0__B_58 BL0__B_59 BL0__B_60 BL0__B_61 BL0__B_62
+  BL0__B_63 BL1_A_32 BL1_A_33 BL1_A_34 BL1_A_35 BL1_A_36 BL1_A_37 BL1_A_38
+  BL1_A_39 BL1_A_40 BL1_A_41 BL1_A_42 BL1_A_43 BL1_A_44 BL1_A_45 BL1_A_46
+  BL1_A_47 BL1_A_48 BL1_A_49 BL1_A_50 BL1_A_51 BL1_A_52 BL1_A_53 BL1_A_54
+  BL1_A_55 BL1_A_56 BL1_A_57 BL1_A_58 BL1_A_59 BL1_A_60 BL1_A_61 BL1_A_62
+  BL1_A_63 BL1_B_32 BL1_B_33 BL1_B_34 BL1_B_35 BL1_B_36 BL1_B_37 BL1_B_38
+  BL1_B_39 BL1_B_40 BL1_B_41 BL1_B_42 BL1_B_43 BL1_B_44 BL1_B_45 BL1_B_46
+  BL1_B_47 BL1_B_48 BL1_B_49 BL1_B_50 BL1_B_51 BL1_B_52 BL1_B_53 BL1_B_54
+  BL1_B_55 BL1_B_56 BL1_B_57 BL1_B_58 BL1_B_59 BL1_B_60 BL1_B_61 BL1_B_62
+  BL1_B_63 BL1__A_32 BL1__A_33 BL1__A_34 BL1__A_35 BL1__A_36 BL1__A_37
+  BL1__A_38 BL1__A_39 BL1__A_40 BL1__A_41 BL1__A_42 BL1__A_43 BL1__A_44
+  BL1__A_45 BL1__A_46 BL1__A_47 BL1__A_48 BL1__A_49 BL1__A_50 BL1__A_51
+  BL1__A_52 BL1__A_53 BL1__A_54 BL1__A_55 BL1__A_56 BL1__A_57 BL1__A_58
+  BL1__A_59 BL1__A_60 BL1__A_61 BL1__A_62 BL1__A_63 BL1__B_32 BL1__B_33
+  BL1__B_34 BL1__B_35 BL1__B_36 BL1__B_37 BL1__B_38 BL1__B_39 BL1__B_40
+  BL1__B_41 BL1__B_42 BL1__B_43 BL1__B_44 BL1__B_45 BL1__B_46 BL1__B_47
+  BL1__B_48 BL1__B_49 BL1__B_50 BL1__B_51 BL1__B_52 BL1__B_53 BL1__B_54
+  BL1__B_55 BL1__B_56 BL1__B_57 BL1__B_58 BL1__B_59 BL1__B_60 BL1__B_61
+  BL1__B_62 BL1__B_63 BL2_A_32 BL2_A_33 BL2_A_34 BL2_A_35 BL2_A_36 BL2_A_37
+  BL2_A_38 BL2_A_39 BL2_A_40 BL2_A_41 BL2_A_42 BL2_A_43 BL2_A_44 BL2_A_45
+  BL2_A_46 BL2_A_47 BL2_A_48 BL2_A_49 BL2_A_50 BL2_A_51 BL2_A_52 BL2_A_53
+  BL2_A_54 BL2_A_55 BL2_A_56 BL2_A_57 BL2_A_58 BL2_A_59 BL2_A_60 BL2_A_61
+  BL2_A_62 BL2_A_63 BL2_B_32 BL2_B_33 BL2_B_34 BL2_B_35 BL2_B_36 BL2_B_37
+  BL2_B_38 BL2_B_39 BL2_B_40 BL2_B_41 BL2_B_42 BL2_B_43 BL2_B_44 BL2_B_45
+  BL2_B_46 BL2_B_47 BL2_B_48 BL2_B_49 BL2_B_50 BL2_B_51 BL2_B_52 BL2_B_53
+  BL2_B_54 BL2_B_55 BL2_B_56 BL2_B_57 BL2_B_58 BL2_B_59 BL2_B_60 BL2_B_61
+  BL2_B_62 BL2_B_63 BL2__A_32 BL2__A_33 BL2__A_34 BL2__A_35 BL2__A_36
+  BL2__A_37 BL2__A_38 BL2__A_39 BL2__A_40 BL2__A_41 BL2__A_42 BL2__A_43
+  BL2__A_44 BL2__A_45 BL2__A_46 BL2__A_47 BL2__A_48 BL2__A_49 BL2__A_50
+  BL2__A_51 BL2__A_52 BL2__A_53 BL2__A_54 BL2__A_55 BL2__A_56 BL2__A_57
+  BL2__A_58 BL2__A_59 BL2__A_60 BL2__A_61 BL2__A_62 BL2__A_63 BL2__B_32
+  BL2__B_33 BL2__B_34 BL2__B_35 BL2__B_36 BL2__B_37 BL2__B_38 BL2__B_39
+  BL2__B_40 BL2__B_41 BL2__B_42 BL2__B_43 BL2__B_44 BL2__B_45 BL2__B_46
+  BL2__B_47 BL2__B_48 BL2__B_49 BL2__B_50 BL2__B_51 BL2__B_52 BL2__B_53
+  BL2__B_54 BL2__B_55 BL2__B_56 BL2__B_57 BL2__B_58 BL2__B_59 BL2__B_60
+  BL2__B_61 BL2__B_62 BL2__B_63 BL3_A_32 BL3_A_33 BL3_A_34 BL3_A_35 BL3_A_36
+  BL3_A_37 BL3_A_38 BL3_A_39 BL3_A_40 BL3_A_41 BL3_A_42 BL3_A_43 BL3_A_44
+  BL3_A_45 BL3_A_46 BL3_A_47 BL3_A_48 BL3_A_49 BL3_A_50 BL3_A_51 BL3_A_52
+  BL3_A_53 BL3_A_54 BL3_A_55 BL3_A_56 BL3_A_57 BL3_A_58 BL3_A_59 BL3_A_60
+  BL3_A_61 BL3_A_62 BL3_A_63 BL3_B_32 BL3_B_33 BL3_B_34 BL3_B_35 BL3_B_36
+  BL3_B_37 BL3_B_38 BL3_B_39 BL3_B_40 BL3_B_41 BL3_B_42 BL3_B_43 BL3_B_44
+  BL3_B_45 BL3_B_46 BL3_B_47 BL3_B_48 BL3_B_49 BL3_B_50 BL3_B_51 BL3_B_52
+  BL3_B_53 BL3_B_54 BL3_B_55 BL3_B_56 BL3_B_57 BL3_B_58 BL3_B_59 BL3_B_60
+  BL3_B_61 BL3_B_62 BL3_B_63 BL3__A_32 BL3__A_33 BL3__A_34 BL3__A_35
+  BL3__A_36 BL3__A_37 BL3__A_38 BL3__A_39 BL3__A_40 BL3__A_41 BL3__A_42
+  BL3__A_43 BL3__A_44 BL3__A_45 BL3__A_46 BL3__A_47 BL3__A_48 BL3__A_49
+  BL3__A_50 BL3__A_51 BL3__A_52 BL3__A_53 BL3__A_54 BL3__A_55 BL3__A_56
+  BL3__A_57 BL3__A_58 BL3__A_59 BL3__A_60 BL3__A_61 BL3__A_62 BL3__A_63
+  BL3__B_32 BL3__B_33 BL3__B_34 BL3__B_35 BL3__B_36 BL3__B_37 BL3__B_38
+  BL3__B_39 BL3__B_40 BL3__B_41 BL3__B_42 BL3__B_43 BL3__B_44 BL3__B_45
+  BL3__B_46 BL3__B_47 BL3__B_48 BL3__B_49 BL3__B_50 BL3__B_51 BL3__B_52
+  BL3__B_53 BL3__B_54 BL3__B_55 BL3__B_56 BL3__B_57 BL3__B_58 BL3__B_59
+  BL3__B_60 BL3__B_61 BL3__B_62 BL3__B_63 BTPSA_A_40 BTPSA_B_42 BTPT_A_36
+  BTPT_B_38 BTPWN_A_46 BTPWN_B_48 BTP_AT BTP_BT DRPREN_AT DRPREN_BT GDL0_32
+  GDL0_33 GDL0_34 GDL0_35 GDL0_36 GDL0_37 GDL0_38 GDL0_39 GDL0_40 GDL0_41
+  GDL0_42 GDL0_43 GDL0_44 GDL0_45 GDL0_46 GDL0_47 GDL0_48 GDL0_49 GDL0_50
+  GDL0_51 GDL0_52 GDL0_53 GDL0_54 GDL0_55 GDL0_56 GDL0_57 GDL0_58 GDL0_59
+  GDL0_60 GDL0_61 GDL0_62 GDL0_63 GDL1_32 GDL1_33 GDL1_34 GDL1_35 GDL1_36
+  GDL1_37 GDL1_38 GDL1_39 GDL1_40 GDL1_41 GDL1_42 GDL1_43 GDL1_44 GDL1_45
+  GDL1_46 GDL1_47 GDL1_48 GDL1_49 GDL1_50 GDL1_51 GDL1_52 GDL1_53 GDL1_54
+  GDL1_55 GDL1_56 GDL1_57 GDL1_58 GDL1_59 GDL1_60 GDL1_61 GDL1_62 GDL1_63
+  GDL2_32 GDL2_33 GDL2_34 GDL2_35 GDL2_36 GDL2_37 GDL2_38 GDL2_39 GDL2_40
+  GDL2_41 GDL2_42 GDL2_43 GDL2_44 GDL2_45 GDL2_46 GDL2_47 GDL2_48 GDL2_49
+  GDL2_50 GDL2_51 GDL2_52 GDL2_53 GDL2_54 GDL2_55 GDL2_56 GDL2_57 GDL2_58
+  GDL2_59 GDL2_60 GDL2_61 GDL2_62 GDL2_63 GDL3_32 GDL3_33 GDL3_34 GDL3_35
+  GDL3_36 GDL3_37 GDL3_38 GDL3_39 GDL3_40 GDL3_41 GDL3_42 GDL3_43 GDL3_44
+  GDL3_45 GDL3_46 GDL3_47 GDL3_48 GDL3_49 GDL3_50 GDL3_51 GDL3_52 GDL3_53
+  GDL3_54 GDL3_55 GDL3_56 GDL3_57 GDL3_58 GDL3_59 GDL3_60 GDL3_61 GDL3_62
+  GDL3_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72
+  GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82
+  GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92
+  GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102
+  GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111
+  GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120
+  GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL__64 GDL__65
+  GDL__66 GDL__67 GDL__68 GDL__69 GDL__70 GDL__71 GDL__72 GDL__73 GDL__74
+  GDL__75 GDL__76 GDL__77 GDL__78 GDL__79 GDL__80 GDL__81 GDL__82 GDL__83
+  GDL__84 GDL__85 GDL__86 GDL__87 GDL__88 GDL__89 GDL__90 GDL__91 GDL__92
+  GDL__93 GDL__94 GDL__95 GDL__96 GDL__97 GDL__98 GDL__99 GDL__100 GDL__101
+  GDL__102 GDL__103 GDL__104 GDL__105 GDL__106 GDL__107 GDL__108 GDL__109
+  GDL__110 GDL__111 GDL__112 GDL__113 GDL__114 GDL__115 GDL__116 GDL__117
+  GDL__118 GDL__119 GDL__120 GDL__121 GDL__122 GDL__123 GDL__124 GDL__125
+  GDL__126 GDL__127 BSAEN_A BSAEN_B TIELO_1 YP0_0_AN YP0_0_BN YP0_1_AN
+  YP0_1_BN YP0_2_AN YP0_2_BN YP0_3_AN YP0_3_BN VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMUXCOL_ROW_HF_R
.ENDS pe_spad_1024x16_dpCHANNEL_0
****
.SUBCKT pe_spad_1024x16_dpCCMWL BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL
+  MWLA MWLB PG1 PG2 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCCMWL: 8 flat devices **
M0 CORED_ MWLB NET65 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N0/N00
M1 NET69 MWLB CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N2/N00
M2 DIFF1 MWLA CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N3/N00
M3 CORED_ MWLA DIFF2 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N4/N00
M4 VDDCE CORED CORED_ VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P1/P00
M5 CORED CORED_ VDDCE VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P0/P00
M6 VSSE CORED_ CORED VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N5/N00
M7 CORED_ CORED VSSE VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N1/N00
.ENDS pe_spad_1024x16_dpCCMWL
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L25 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L25: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L25
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L80 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L80: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L80
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L63 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L63: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L63
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L46 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L46: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L46
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L84 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L84: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L84
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L67 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L67: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L67
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L88 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L88: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L88
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L101 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L101: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L101
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L122 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L122: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L122
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L105 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L105: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L105
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L126 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L126: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L126
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L9 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L9: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L9
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L30 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L30: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L30
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L13 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L13: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L13
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L51 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L51: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L51
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L34 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L34: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L34
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L89 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L89: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L89
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L17 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L17: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L17
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L72 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L72: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L72
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L55 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L55: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L55
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L38 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L38: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L38
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L93 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L93: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L93
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L76 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L76: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L76
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L97 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L97: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L97
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L110 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L110: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L110
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L2 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L2: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L2
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L6 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L6: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L6
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L114 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L114: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L114
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L118 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L118: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L118
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L39 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L39: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L39
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L22 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L22: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L22
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L60 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L60: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L60
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L43 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L43: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L43
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L26 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L26: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L26
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L81 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L81: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L81
****
.SUBCKT pe_spad_1024x16_dpFLMW BLA BLA_ BLB BLB_ CORED CORED1 CORED1_ CORED_
+  GDL MWLL PG1 PG2 WLA1 WLA2 WLB VDDPE VDDCE VSSE
** pe_spad_1024x16_dpFLMW: 16 flat devices **
M0 VSSE CORED_ CORED VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N5/N00
M1 CORED_ CORED VSSE VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N1/N00
M10 NET128 WLA1 CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N3/N00
M11 CORED_ WLA1 NET124 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N4/N00
M12 CORED1_ WLA1 NET124 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N8/N00
M13 NET128 WLA1 CORED1 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N9/N00
M14 NET0135 WLB CORED1 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N10/N00
M15 CORED1_ WLB NET133 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N11/N00
M2 VSSE CORED1_ CORED1 VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N6/N00
M3 CORED1_ CORED1 VSSE VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N7/N00
M4 VDDCE CORED CORED_ VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P1/P00
M5 CORED CORED_ VDDCE VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P0/P00
M6 VDDCE CORED1 CORED1_ VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P2/P00
M7 CORED1 CORED1_ VDDCE VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P3/P00
M8 CORED_ WLB NET112 VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N0/N00
M9 NET116 WLB CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N2/N00
.ENDS pe_spad_1024x16_dpFLMW
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L64 BLA BLA_ BLB BLB_ GDL MWLL PG1 PG2
+  TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 WLA1 WLA2 WLB VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L64: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED1 CORED1_ CORED_ GDL MWLL PG1 PG2 WLA1 WLA2
+  WLB VDDPE VDDCE VSSE pe_spad_1024x16_dpFLMW
.ENDS pe_spad_1024x16_dpMWL_COL_L64
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L47 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L47: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L47
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L85 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L85: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L85
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L68 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L68: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L68
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L119 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L119: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L119
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L102 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L102: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L102
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L123 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L123: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L123
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L106 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L106: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L106
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L127 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L127: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L127
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L10 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L10: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L10
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L31 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L31: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L31
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L14 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L14: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L14
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L69 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L69: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L69
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L52 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L52: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L52
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L35 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L35: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L35
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L90 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L90: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L90
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L18 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L18: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L18
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L73 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L73: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L73
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L56 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L56: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L56
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L94 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L94: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L94
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L77 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L77: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L77
****
.SUBCKT pe_spad_1024x16_dpCCEDGE_CCMBL BLA BLA_ BLB_ CORED CORED_ GDL MBL
+  NDIFF PDIFF PG1 PG2 TIELO WLA WLB VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCCEDGE_CCMBL: 8 flat devices **
M0 CORED_ TIELO BLB_ VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N0/N00
M1 MBL TIELO CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N2/N00
M2 BLA WLA CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N3/N00
M3 CORED_ WLA BLA_ VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N4/N00
M4 PDIFF CORED CORED_ VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P1/P00
M5 CORED CORED_ VDDCE VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P0/P00
M6 NDIFF CORED_ CORED VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N5/N00
M7 CORED_ CORED VSSE VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N1/N00
.ENDS pe_spad_1024x16_dpCCEDGE_CCMBL
****
.SUBCKT pe_spad_1024x16_dpMWL_EDGE_L BLA BLA_ BLB_ GDL MBL PG1 PG2 TIEHI_0
+  TIEHI_1 TIELO WLA_0 WLA_1 WLB_0 WLB_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_EDGE_L: 16 flat devices **
XI0_1 BLA BLA_ BLB_ CORED CORED_ GDL MBL NDIFF PDIFF PG1 PG2 TIELO WLA_0 WLB_0
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_2 BLA BLA_ BLB_ CORED_8 CORED__6 GDL MBL NDIFF PDIFF_4 PG1 PG2 TIELO WLA_1
+  WLB_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
.ENDS pe_spad_1024x16_dpMWL_EDGE_L
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L98 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L98: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L98
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L111 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L111: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L111
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L3 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L3: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L3
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L7 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L7: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L7
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L115 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L115: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L115
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L19 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L19: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L19
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L40 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L40: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L40
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L23 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L23: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L23
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L61 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L61: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L61
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L44 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L44: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L44
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L27 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L27: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L27
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L82 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L82: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L82
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L65 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L65: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L65
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L48 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L48: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L48
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L86 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L86: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L86
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L99 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L99: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L99
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L120 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L120: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L120
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L103 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L103: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L103
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L124 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L124: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L124
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L107 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L107: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L107
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L11 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L11: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L11
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L49 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L49: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L49
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L32 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L32: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L32
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L15 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L15: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L15
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L70 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L70: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L70
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L53 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L53: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L53
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L36 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L36: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L36
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L91 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L91: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L91
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L74 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L74: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L74
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L57 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L57: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L57
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L95 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L95: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L95
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L78 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L78: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L78
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L0 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L0: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L0
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L4 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L4: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L4
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L112 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L112: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L112
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L8 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L8: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L8
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L116 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L116: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L116
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L20 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L20: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L20
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L41 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L41: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L41
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L24 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L24: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L24
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L79 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L79: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L79
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L62 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L62: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L62
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L45 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L45: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L45
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L28 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L28: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L28
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L83 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L83: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L83
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L66 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L66: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L66
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L87 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L87: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L87
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L100 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L100: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L100
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L121 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L121: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L121
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L104 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L104: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L104
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L125 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L125: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L125
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L108 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L108: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L108
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L29 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L29: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L29
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L12 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L12: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L12
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L50 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L50: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L50
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L33 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L33: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L33
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L16 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L16: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L16
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L71 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L71: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L71
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L54 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L54: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L54
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L37 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L37: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L37
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L92 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L92: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L92
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L75 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L75: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L75
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L58 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L58: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L58
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L96 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L96: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L96
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L109 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L109: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L109
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L1 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L1: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L1
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L5 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L5: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L5
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L113 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L113: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L113
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L117 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L117: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L117
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L21 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L21: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L21
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L59 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L59: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L59
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_L42 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_L42: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_L42
****
.SUBCKT pe_spad_1024x16_dpMWL_ROW_L BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6
+  BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17
+  BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27
+  BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37
+  BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47
+  BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57
+  BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67
+  BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76 BLA_77
+  BLA_78 BLA_79 BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86 BLA_87
+  BLA_88 BLA_89 BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96 BLA_97
+  BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105 BLA_106
+  BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114 BLA_115
+  BLA_116 BLA_117 BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123 BLA_124
+  BLA_125 BLA_126 BLA_127 BLA_128 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5
+  BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78
+  BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87
+  BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96
+  BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104
+  BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112
+  BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120
+  BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLA__128
+  BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11
+  BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21
+  BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31
+  BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41
+  BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51
+  BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61
+  BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71
+  BLB_72 BLB_73 BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81
+  BLB_82 BLB_83 BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91
+  BLB_92 BLB_93 BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101
+  BLB_102 BLB_103 BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110
+  BLB_111 BLB_112 BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119
+  BLB_120 BLB_121 BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB__0
+  BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10
+  BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19
+  BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28
+  BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37
+  BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46
+  BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55
+  BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64
+  BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73
+  BLB__74 BLB__75 BLB__76 BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82
+  BLB__83 BLB__84 BLB__85 BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91
+  BLB__92 BLB__93 BLB__94 BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100
+  BLB__101 BLB__102 BLB__103 BLB__104 BLB__105 BLB__106 BLB__107 BLB__108
+  BLB__109 BLB__110 BLB__111 BLB__112 BLB__113 BLB__114 BLB__115 BLB__116
+  BLB__117 BLB__118 BLB__119 BLB__120 BLB__121 BLB__122 BLB__123 BLB__124
+  BLB__125 BLB__126 BLB__127 BLB__128 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26
+  GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36
+  GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46
+  GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56
+  GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66
+  GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76
+  GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86
+  GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96
+  GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105
+  GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114
+  GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123
+  GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 MBL PG1_0 PG1_1 PG1_2 PG1_3 PG1_4
+  PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15
+  PG1_16 PG1_17 PG1_18 PG1_19 PG1_20 PG1_21 PG1_22 PG1_23 PG1_24 PG1_25
+  PG1_26 PG1_27 PG1_28 PG1_29 PG1_30 PG1_31 PG1_32 PG1_33 PG1_34 PG1_35
+  PG1_36 PG1_37 PG1_38 PG1_39 PG1_40 PG1_41 PG1_42 PG1_43 PG1_44 PG1_45
+  PG1_46 PG1_47 PG1_48 PG1_49 PG1_50 PG1_51 PG1_52 PG1_53 PG1_54 PG1_55
+  PG1_56 PG1_57 PG1_58 PG1_59 PG1_60 PG1_61 PG1_62 PG1_63 PG1_64 PG1_65
+  PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71 PG1_72 PG1_73 PG1_74 PG1_75
+  PG1_76 PG1_77 PG1_78 PG1_79 PG1_80 PG1_81 PG1_82 PG1_83 PG1_84 PG1_85
+  PG1_86 PG1_87 PG1_88 PG1_89 PG1_90 PG1_91 PG1_92 PG1_93 PG1_94 PG1_95
+  PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101 PG1_102 PG1_103 PG1_104 PG1_105
+  PG1_106 PG1_107 PG1_108 PG1_109 PG1_110 PG1_111 PG1_112 PG1_113 PG1_114
+  PG1_115 PG1_116 PG1_117 PG1_118 PG1_119 PG1_120 PG1_121 PG1_122 PG1_123
+  PG1_124 PG1_125 PG1_126 PG1_127 PG1_128 PG2_0 PG2_1 PG2_2 PG2_3 PG2_4 PG2_5
+  PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12 PG2_13 PG2_14 PG2_15 PG2_16
+  PG2_17 PG2_18 PG2_19 PG2_20 PG2_21 PG2_22 PG2_23 PG2_24 PG2_25 PG2_26
+  PG2_27 PG2_28 PG2_29 PG2_30 PG2_31 PG2_32 PG2_33 PG2_34 PG2_35 PG2_36
+  PG2_37 PG2_38 PG2_39 PG2_40 PG2_41 PG2_42 PG2_43 PG2_44 PG2_45 PG2_46
+  PG2_47 PG2_48 PG2_49 PG2_50 PG2_51 PG2_52 PG2_53 PG2_54 PG2_55 PG2_56
+  PG2_57 PG2_58 PG2_59 PG2_60 PG2_61 PG2_62 PG2_63 PG2_64 PG2_65 PG2_66
+  PG2_67 PG2_68 PG2_69 PG2_70 PG2_71 PG2_72 PG2_73 PG2_74 PG2_75 PG2_76
+  PG2_77 PG2_78 PG2_79 PG2_80 PG2_81 PG2_82 PG2_83 PG2_84 PG2_85 PG2_86
+  PG2_87 PG2_88 PG2_89 PG2_90 PG2_91 PG2_92 PG2_93 PG2_94 PG2_95 PG2_96
+  PG2_97 PG2_98 PG2_99 PG2_100 PG2_101 PG2_102 PG2_103 PG2_104 PG2_105
+  PG2_106 PG2_107 PG2_108 PG2_109 PG2_110 PG2_111 PG2_112 PG2_113 PG2_114
+  PG2_115 PG2_116 PG2_117 PG2_118 PG2_119 PG2_120 PG2_121 PG2_122 PG2_123
+  PG2_124 PG2_125 PG2_126 PG2_127 PG2_128 TIEHI_0 TIEHI_1 TIELO WLA WLB VDDPE
+  VDDCE VSSE
** pe_spad_1024x16_dpMWL_ROW_L: 2064 flat devices **
XI0_0 BLA_0 BLA__0 BLB__0 GDL_0 MBL PG1_0 PG2_0 TIEHI_0 TIEHI_1 TIELO WLA WLA
+  WLB WLB VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_EDGE_L
XI100_0 BLA_100 BLA__100 BLB_99 BLB__100 GDL_100 TIELO TIELO TIELO TIELO
+  PG1_100 PG2_100 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L99
XI101_0 BLA_101 BLA__101 BLB_100 BLB__101 GDL_101 TIELO TIELO TIELO TIELO
+  PG1_101 PG2_101 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L100
XI102_0 BLA_102 BLA__102 BLB_101 BLB__102 GDL_102 TIELO TIELO TIELO TIELO
+  PG1_102 PG2_102 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L101
XI103_0 BLA_103 BLA__103 BLB_102 BLB__103 GDL_103 TIELO TIELO TIELO TIELO
+  PG1_103 PG2_103 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L102
XI104_0 BLA_104 BLA__104 BLB_103 BLB__104 GDL_104 TIELO TIELO TIELO TIELO
+  PG1_104 PG2_104 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L103
XI105_0 BLA_105 BLA__105 BLB_104 BLB__105 GDL_105 TIELO TIELO TIELO TIELO
+  PG1_105 PG2_105 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L104
XI106_0 BLA_106 BLA__106 BLB_105 BLB__106 GDL_106 TIELO TIELO TIELO TIELO
+  PG1_106 PG2_106 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L105
XI107_0 BLA_107 BLA__107 BLB_106 BLB__107 GDL_107 TIELO TIELO TIELO TIELO
+  PG1_107 PG2_107 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L106
XI108_0 BLA_108 BLA__108 BLB_107 BLB__108 GDL_108 TIELO TIELO TIELO TIELO
+  PG1_108 PG2_108 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L107
XI109_0 BLA_109 BLA__109 BLB_108 BLB__109 GDL_109 TIELO TIELO TIELO TIELO
+  PG1_109 PG2_109 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L108
XI10_0 BLA_10 BLA__10 BLB_9 BLB__10 GDL_10 WLA WLA WLB WLB PG1_10 PG2_10
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L9
XI110_0 BLA_110 BLA__110 BLB_109 BLB__110 GDL_110 TIELO TIELO TIELO TIELO
+  PG1_110 PG2_110 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L109
XI111_0 BLA_111 BLA__111 BLB_110 BLB__111 GDL_111 TIELO TIELO TIELO TIELO
+  PG1_111 PG2_111 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L110
XI112_0 BLA_112 BLA__112 BLB_111 BLB__112 GDL_112 TIELO TIELO TIELO TIELO
+  PG1_112 PG2_112 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L111
XI113_0 BLA_113 BLA__113 BLB_112 BLB__113 GDL_113 TIELO TIELO TIELO TIELO
+  PG1_113 PG2_113 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L112
XI114_0 BLA_114 BLA__114 BLB_113 BLB__114 GDL_114 TIELO TIELO TIELO TIELO
+  PG1_114 PG2_114 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L113
XI115_0 BLA_115 BLA__115 BLB_114 BLB__115 GDL_115 TIELO TIELO TIELO TIELO
+  PG1_115 PG2_115 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L114
XI116_0 BLA_116 BLA__116 BLB_115 BLB__116 GDL_116 TIELO TIELO TIELO TIELO
+  PG1_116 PG2_116 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L115
XI117_0 BLA_117 BLA__117 BLB_116 BLB__117 GDL_117 TIELO TIELO TIELO TIELO
+  PG1_117 PG2_117 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L116
XI118_0 BLA_118 BLA__118 BLB_117 BLB__118 GDL_118 TIELO TIELO TIELO TIELO
+  PG1_118 PG2_118 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L117
XI119_0 BLA_119 BLA__119 BLB_118 BLB__119 GDL_119 TIELO TIELO TIELO TIELO
+  PG1_119 PG2_119 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L118
XI11_0 BLA_11 BLA__11 BLB_10 BLB__11 GDL_11 WLA WLA WLB WLB PG1_11 PG2_11
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L10
XI120_0 BLA_120 BLA__120 BLB_119 BLB__120 GDL_120 TIELO TIELO TIELO TIELO
+  PG1_120 PG2_120 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L119
XI121_0 BLA_121 BLA__121 BLB_120 BLB__121 GDL_121 TIELO TIELO TIELO TIELO
+  PG1_121 PG2_121 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L120
XI122_0 BLA_122 BLA__122 BLB_121 BLB__122 GDL_122 TIELO TIELO TIELO TIELO
+  PG1_122 PG2_122 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L121
XI123_0 BLA_123 BLA__123 BLB_122 BLB__123 GDL_123 TIELO TIELO TIELO TIELO
+  PG1_123 PG2_123 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L122
XI124_0 BLA_124 BLA__124 BLB_123 BLB__124 GDL_124 TIELO TIELO TIELO TIELO
+  PG1_124 PG2_124 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L123
XI125_0 BLA_125 BLA__125 BLB_124 BLB__125 GDL_125 TIELO TIELO TIELO TIELO
+  PG1_125 PG2_125 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L124
XI126_0 BLA_126 BLA__126 BLB_125 BLB__126 GDL_126 TIELO TIELO TIELO TIELO
+  PG1_126 PG2_126 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L125
XI127_0 BLA_127 BLA__127 BLB_126 BLB__127 GDL_127 TIELO TIELO TIELO TIELO
+  PG1_127 PG2_127 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L126
XI128_0 BLA_128 BLA__128 BLB_127 BLB__128 GDL_128 TIELO TIELO TIELO TIELO
+  PG1_128 PG2_128 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L127
XI12_0 BLA_12 BLA__12 BLB_11 BLB__12 GDL_12 WLA WLA WLB WLB PG1_12 PG2_12
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L11
XI13_0 BLA_13 BLA__13 BLB_12 BLB__13 GDL_13 WLA WLA WLB WLB PG1_13 PG2_13
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L12
XI14_0 BLA_14 BLA__14 BLB_13 BLB__14 GDL_14 WLA WLA WLB WLB PG1_14 PG2_14
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L13
XI15_0 BLA_15 BLA__15 BLB_14 BLB__15 GDL_15 WLA WLA WLB WLB PG1_15 PG2_15
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L14
XI16_0 BLA_16 BLA__16 BLB_15 BLB__16 GDL_16 WLA WLA WLB WLB PG1_16 PG2_16
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L15
XI17_0 BLA_17 BLA__17 BLB_16 BLB__17 GDL_17 WLA WLA WLB WLB PG1_17 PG2_17
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L16
XI18_0 BLA_18 BLA__18 BLB_17 BLB__18 GDL_18 WLA WLA WLB WLB PG1_18 PG2_18
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L17
XI19_0 BLA_19 BLA__19 BLB_18 BLB__19 GDL_19 WLA WLA WLB WLB PG1_19 PG2_19
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L18
XI1_0 BLA_1 BLA__1 BLB_0 BLB__1 GDL_1 WLA WLA WLB WLB PG1_1 PG2_1 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L0
XI20_0 BLA_20 BLA__20 BLB_19 BLB__20 GDL_20 WLA WLA WLB WLB PG1_20 PG2_20
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L19
XI21_0 BLA_21 BLA__21 BLB_20 BLB__21 GDL_21 WLA WLA WLB WLB PG1_21 PG2_21
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L20
XI22_0 BLA_22 BLA__22 BLB_21 BLB__22 GDL_22 WLA WLA WLB WLB PG1_22 PG2_22
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L21
XI23_0 BLA_23 BLA__23 BLB_22 BLB__23 GDL_23 WLA WLA WLB WLB PG1_23 PG2_23
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L22
XI24_0 BLA_24 BLA__24 BLB_23 BLB__24 GDL_24 WLA WLA WLB WLB PG1_24 PG2_24
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L23
XI25_0 BLA_25 BLA__25 BLB_24 BLB__25 GDL_25 WLA WLA WLB WLB PG1_25 PG2_25
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L24
XI26_0 BLA_26 BLA__26 BLB_25 BLB__26 GDL_26 WLA WLA WLB WLB PG1_26 PG2_26
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L25
XI27_0 BLA_27 BLA__27 BLB_26 BLB__27 GDL_27 WLA WLA WLB WLB PG1_27 PG2_27
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L26
XI28_0 BLA_28 BLA__28 BLB_27 BLB__28 GDL_28 WLA WLA WLB WLB PG1_28 PG2_28
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L27
XI29_0 BLA_29 BLA__29 BLB_28 BLB__29 GDL_29 WLA WLA WLB WLB PG1_29 PG2_29
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L28
XI2_0 BLA_2 BLA__2 BLB_1 BLB__2 GDL_2 WLA WLA WLB WLB PG1_2 PG2_2 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L1
XI30_0 BLA_30 BLA__30 BLB_29 BLB__30 GDL_30 WLA WLA WLB WLB PG1_30 PG2_30
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L29
XI31_0 BLA_31 BLA__31 BLB_30 BLB__31 GDL_31 WLA WLA WLB WLB PG1_31 PG2_31
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L30
XI32_0 BLA_32 BLA__32 BLB_31 BLB__32 GDL_32 WLA WLA WLB WLB PG1_32 PG2_32
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L31
XI33_0 BLA_33 BLA__33 BLB_32 BLB__33 GDL_33 WLA WLA WLB WLB PG1_33 PG2_33
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L32
XI34_0 BLA_34 BLA__34 BLB_33 BLB__34 GDL_34 WLA WLA WLB WLB PG1_34 PG2_34
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L33
XI35_0 BLA_35 BLA__35 BLB_34 BLB__35 GDL_35 WLA WLA WLB WLB PG1_35 PG2_35
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L34
XI36_0 BLA_36 BLA__36 BLB_35 BLB__36 GDL_36 WLA WLA WLB WLB PG1_36 PG2_36
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L35
XI37_0 BLA_37 BLA__37 BLB_36 BLB__37 GDL_37 WLA WLA WLB WLB PG1_37 PG2_37
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L36
XI38_0 BLA_38 BLA__38 BLB_37 BLB__38 GDL_38 WLA WLA WLB WLB PG1_38 PG2_38
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L37
XI39_0 BLA_39 BLA__39 BLB_38 BLB__39 GDL_39 WLA WLA WLB WLB PG1_39 PG2_39
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L38
XI3_0 BLA_3 BLA__3 BLB_2 BLB__3 GDL_3 WLA WLA WLB WLB PG1_3 PG2_3 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L2
XI40_0 BLA_40 BLA__40 BLB_39 BLB__40 GDL_40 WLA WLA WLB WLB PG1_40 PG2_40
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L39
XI41_0 BLA_41 BLA__41 BLB_40 BLB__41 GDL_41 WLA WLA WLB WLB PG1_41 PG2_41
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L40
XI42_0 BLA_42 BLA__42 BLB_41 BLB__42 GDL_42 WLA WLA WLB WLB PG1_42 PG2_42
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L41
XI43_0 BLA_43 BLA__43 BLB_42 BLB__43 GDL_43 WLA WLA WLB WLB PG1_43 PG2_43
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L42
XI44_0 BLA_44 BLA__44 BLB_43 BLB__44 GDL_44 WLA WLA WLB WLB PG1_44 PG2_44
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L43
XI45_0 BLA_45 BLA__45 BLB_44 BLB__45 GDL_45 WLA WLA WLB WLB PG1_45 PG2_45
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L44
XI46_0 BLA_46 BLA__46 BLB_45 BLB__46 GDL_46 WLA WLA WLB WLB PG1_46 PG2_46
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L45
XI47_0 BLA_47 BLA__47 BLB_46 BLB__47 GDL_47 WLA WLA WLB WLB PG1_47 PG2_47
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L46
XI48_0 BLA_48 BLA__48 BLB_47 BLB__48 GDL_48 WLA WLA WLB WLB PG1_48 PG2_48
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L47
XI49_0 BLA_49 BLA__49 BLB_48 BLB__49 GDL_49 WLA WLA WLB WLB PG1_49 PG2_49
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L48
XI4_0 BLA_4 BLA__4 BLB_3 BLB__4 GDL_4 WLA WLA WLB WLB PG1_4 PG2_4 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L3
XI50_0 BLA_50 BLA__50 BLB_49 BLB__50 GDL_50 WLA WLA WLB WLB PG1_50 PG2_50
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L49
XI51_0 BLA_51 BLA__51 BLB_50 BLB__51 GDL_51 WLA WLA WLB WLB PG1_51 PG2_51
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L50
XI52_0 BLA_52 BLA__52 BLB_51 BLB__52 GDL_52 WLA WLA WLB WLB PG1_52 PG2_52
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L51
XI53_0 BLA_53 BLA__53 BLB_52 BLB__53 GDL_53 WLA WLA WLB WLB PG1_53 PG2_53
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L52
XI54_0 BLA_54 BLA__54 BLB_53 BLB__54 GDL_54 WLA WLA WLB WLB PG1_54 PG2_54
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L53
XI55_0 BLA_55 BLA__55 BLB_54 BLB__55 GDL_55 WLA WLA WLB WLB PG1_55 PG2_55
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L54
XI56_0 BLA_56 BLA__56 BLB_55 BLB__56 GDL_56 WLA WLA WLB WLB PG1_56 PG2_56
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L55
XI57_0 BLA_57 BLA__57 BLB_56 BLB__57 GDL_57 WLA WLA WLB WLB PG1_57 PG2_57
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L56
XI58_0 BLA_58 BLA__58 BLB_57 BLB__58 GDL_58 WLA WLA WLB WLB PG1_58 PG2_58
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L57
XI59_0 BLA_59 BLA__59 BLB_58 BLB__59 GDL_59 WLA WLA WLB WLB PG1_59 PG2_59
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L58
XI5_0 BLA_5 BLA__5 BLB_4 BLB__5 GDL_5 WLA WLA WLB WLB PG1_5 PG2_5 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L4
XI60_0 BLA_60 BLA__60 BLB_59 BLB__60 GDL_60 WLA WLA WLB WLB PG1_60 PG2_60
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L59
XI61_0 BLA_61 BLA__61 BLB_60 BLB__61 GDL_61 WLA WLA WLB WLB PG1_61 PG2_61
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L60
XI62_0 BLA_62 BLA__62 BLB_61 BLB__62 GDL_62 WLA WLA WLB WLB PG1_62 PG2_62
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L61
XI63_0 BLA_63 BLA__63 BLB_62 BLB__63 GDL_63 WLA WLA WLB WLB PG1_63 PG2_63
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L62
XI64_0 BLA_64 BLA__64 BLB_63 BLB__64 GDL_64 WLA WLA WLB WLB PG1_64 PG2_64
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L63
XI65_0 BLA_65 BLA__65 BLB_64 BLB__65 GDL_65 WLB PG1_65 PG2_65 TIEHI_0 TIEHI_1
+  TIELO TIELO WLA TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L64
XI66_0 BLA_66 BLA__66 BLB_65 BLB__66 GDL_66 TIELO TIELO TIELO TIELO PG1_66
+  PG2_66 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L65
XI67_0 BLA_67 BLA__67 BLB_66 BLB__67 GDL_67 TIELO TIELO TIELO TIELO PG1_67
+  PG2_67 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L66
XI68_0 BLA_68 BLA__68 BLB_67 BLB__68 GDL_68 TIELO TIELO TIELO TIELO PG1_68
+  PG2_68 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L67
XI69_0 BLA_69 BLA__69 BLB_68 BLB__69 GDL_69 TIELO TIELO TIELO TIELO PG1_69
+  PG2_69 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L68
XI6_0 BLA_6 BLA__6 BLB_5 BLB__6 GDL_6 WLA WLA WLB WLB PG1_6 PG2_6 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L5
XI70_0 BLA_70 BLA__70 BLB_69 BLB__70 GDL_70 TIELO TIELO TIELO TIELO PG1_70
+  PG2_70 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L69
XI71_0 BLA_71 BLA__71 BLB_70 BLB__71 GDL_71 TIELO TIELO TIELO TIELO PG1_71
+  PG2_71 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L70
XI72_0 BLA_72 BLA__72 BLB_71 BLB__72 GDL_72 TIELO TIELO TIELO TIELO PG1_72
+  PG2_72 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L71
XI73_0 BLA_73 BLA__73 BLB_72 BLB__73 GDL_73 TIELO TIELO TIELO TIELO PG1_73
+  PG2_73 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L72
XI74_0 BLA_74 BLA__74 BLB_73 BLB__74 GDL_74 TIELO TIELO TIELO TIELO PG1_74
+  PG2_74 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L73
XI75_0 BLA_75 BLA__75 BLB_74 BLB__75 GDL_75 TIELO TIELO TIELO TIELO PG1_75
+  PG2_75 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L74
XI76_0 BLA_76 BLA__76 BLB_75 BLB__76 GDL_76 TIELO TIELO TIELO TIELO PG1_76
+  PG2_76 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L75
XI77_0 BLA_77 BLA__77 BLB_76 BLB__77 GDL_77 TIELO TIELO TIELO TIELO PG1_77
+  PG2_77 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L76
XI78_0 BLA_78 BLA__78 BLB_77 BLB__78 GDL_78 TIELO TIELO TIELO TIELO PG1_78
+  PG2_78 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L77
XI79_0 BLA_79 BLA__79 BLB_78 BLB__79 GDL_79 TIELO TIELO TIELO TIELO PG1_79
+  PG2_79 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L78
XI7_0 BLA_7 BLA__7 BLB_6 BLB__7 GDL_7 WLA WLA WLB WLB PG1_7 PG2_7 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L6
XI80_0 BLA_80 BLA__80 BLB_79 BLB__80 GDL_80 TIELO TIELO TIELO TIELO PG1_80
+  PG2_80 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L79
XI81_0 BLA_81 BLA__81 BLB_80 BLB__81 GDL_81 TIELO TIELO TIELO TIELO PG1_81
+  PG2_81 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L80
XI82_0 BLA_82 BLA__82 BLB_81 BLB__82 GDL_82 TIELO TIELO TIELO TIELO PG1_82
+  PG2_82 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L81
XI83_0 BLA_83 BLA__83 BLB_82 BLB__83 GDL_83 TIELO TIELO TIELO TIELO PG1_83
+  PG2_83 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L82
XI84_0 BLA_84 BLA__84 BLB_83 BLB__84 GDL_84 TIELO TIELO TIELO TIELO PG1_84
