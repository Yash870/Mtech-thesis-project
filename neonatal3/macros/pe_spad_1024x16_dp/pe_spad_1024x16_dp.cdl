+  PG2_84 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L83
XI85_0 BLA_85 BLA__85 BLB_84 BLB__85 GDL_85 TIELO TIELO TIELO TIELO PG1_85
+  PG2_85 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L84
XI86_0 BLA_86 BLA__86 BLB_85 BLB__86 GDL_86 TIELO TIELO TIELO TIELO PG1_86
+  PG2_86 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L85
XI87_0 BLA_87 BLA__87 BLB_86 BLB__87 GDL_87 TIELO TIELO TIELO TIELO PG1_87
+  PG2_87 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L86
XI88_0 BLA_88 BLA__88 BLB_87 BLB__88 GDL_88 TIELO TIELO TIELO TIELO PG1_88
+  PG2_88 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L87
XI89_0 BLA_89 BLA__89 BLB_88 BLB__89 GDL_89 TIELO TIELO TIELO TIELO PG1_89
+  PG2_89 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L88
XI8_0 BLA_8 BLA__8 BLB_7 BLB__8 GDL_8 WLA WLA WLB WLB PG1_8 PG2_8 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L7
XI90_0 BLA_90 BLA__90 BLB_89 BLB__90 GDL_90 TIELO TIELO TIELO TIELO PG1_90
+  PG2_90 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L89
XI91_0 BLA_91 BLA__91 BLB_90 BLB__91 GDL_91 TIELO TIELO TIELO TIELO PG1_91
+  PG2_91 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L90
XI92_0 BLA_92 BLA__92 BLB_91 BLB__92 GDL_92 TIELO TIELO TIELO TIELO PG1_92
+  PG2_92 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L91
XI93_0 BLA_93 BLA__93 BLB_92 BLB__93 GDL_93 TIELO TIELO TIELO TIELO PG1_93
+  PG2_93 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L92
XI94_0 BLA_94 BLA__94 BLB_93 BLB__94 GDL_94 TIELO TIELO TIELO TIELO PG1_94
+  PG2_94 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L93
XI95_0 BLA_95 BLA__95 BLB_94 BLB__95 GDL_95 TIELO TIELO TIELO TIELO PG1_95
+  PG2_95 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L94
XI96_0 BLA_96 BLA__96 BLB_95 BLB__96 GDL_96 TIELO TIELO TIELO TIELO PG1_96
+  PG2_96 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L95
XI97_0 BLA_97 BLA__97 BLB_96 BLB__97 GDL_97 TIELO TIELO TIELO TIELO PG1_97
+  PG2_97 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L96
XI98_0 BLA_98 BLA__98 BLB_97 BLB__98 GDL_98 TIELO TIELO TIELO TIELO PG1_98
+  PG2_98 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L97
XI99_0 BLA_99 BLA__99 BLB_98 BLB__99 GDL_99 TIELO TIELO TIELO TIELO PG1_99
+  PG2_99 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_L98
XI9_0 BLA_9 BLA__9 BLB_8 BLB__9 GDL_9 WLA WLA WLB WLB PG1_9 PG2_9 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_L8
.ENDS pe_spad_1024x16_dpMWL_ROW_L
****
.SUBCKT pe_spad_1024x16_dpMWD_HALF AX0TRACK AX1TRACK AX2TRACK AX3TRACK
+  AX4TRACK AX5TRACK AY0TRACK AY1TRACK BS0N BS1N BS2N BTP GTP GTPD GTPDE GTPIN
+  GTPMW LGWE LGWET MBL MBLIN MGDLE MGDLS MGTPE MGTPS MWL MWL_B P1 P2 P3 P4 P5
+  P6 P7 P8 P9 P10 P11 P12 P13 PW1 PW2 PW3 RBTPTERM RDTN RET RRA0 RRA0_ RRA1
+  RRA1_ RREN TIEHI TIELO WBT XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10
+  XP11 XP12 XP13 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWD_HALF: 56 flat devices **
M0 NET252 MWL NET375 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/mblpg/N00
M1 VSSE WBT NET254 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N9/N00
M10 MBL MWL NET291 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N6/N00
M11 P2 MWL NET276 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N59/N00
M12 VSSE WBT NET287 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N5/N00
M13 NET291 WBT VSSE VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N4/N00
M14 VSSE NET337 NET293 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N39/N00
M15 NET293 MWL PW3 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N38/N00
M16 VSSE NET337 NET299 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N37/N00
M17 VSSE NET337 NET302 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N36/N00
M18 NET306 TIEHI VSSE VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N35/N00
M19 NET299 MWL PW1 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N34/N00
M2 P6 MWL NET260 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N86/N00
M20 VSSE TIEHI NET311 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N33/N00
M21 VSSE TIEHI NET314 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N32/N00
M22 VSSE TIEHI NET317 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N31/N00
M23 NET302 MWL PW2 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N30/N00
M24 NET311 MWL P8 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N29/N00
M25 P5 MWL NET306 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N28/N00
M26 VSSE TIEHI NET329 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N26/N00
M27 VSSE NET337 NET332 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N25/N00
M28 NET329 MWL P11 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N24/N00
M29 VSSE NET337 MBL0 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N23/N00
M3 VSSE TIEHI NET260 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N85/N00
M30 NET317 MWL P9 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N22/N00
M31 NET314 MWL P4 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N21/N00
M32 VSSE TIEHI NET347 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N19/N00
M33 NET347 MWL P10 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N18/N00
M34 MBL MWL MBL0 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N16/N00
M35 NET359 MWL NET356 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N15/N00
M36 VSSE WBT NET359 VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N14/N00
M37 P12 MWL NET369 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N13/N00
M38 NET254 MWL P13 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N11/N00
M39 NET369 WBT VSSE VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N10/N00
M4 NET287 MWL MBL VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N8/N00
M40 P1 MWL NET332 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N1/N00
M41 NET375 TIEHI VSSE VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N0/N00
M42 MBL NET0381 MBLIN VDDCE PCH W=0.3U L=0.06U M=1 $name=/P23/P00
M43 GTPIN TIELO GTPAT VDDCE PCH W=1.6U L=0.06U M=1 $name=/tppass0/P00
M44 MBLIN NET337 MBL VSSE NCH W=0.3U L=0.06U M=1 $name=/N42/N00
M45 VSSE RET GTPAT VSSE NCH W=0.15U L=0.06U M=1 $name=/N2/N00
M46 VSSE RET MWL_B VSSE NCH W=0.15U L=0.06U M=1 $name=/N3/N00
M47 GTPAT TIEHI GTPIN VSSE NCH W=1.6U L=0.06U M=1 $name=/tnpass0/N00
M48 NET0381 NET337 VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I2/N00
M49 VDDPE NET337 NET0381 VDDCE PCH W=0.3U L=0.06U M=1 $name=/I2/P00
M5 NET267 TIEHI VSSE VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N77/N00
M50 MWL_B NET390 VSSE VSSE NCH W=8U L=0.06U M=1 $name=/gwldrv/N00
M51 VDDCE NET390 MWL_B VDDCE PCH W=14U L=0.06U M=1 $name=/gwldrv/P00
M52 NET390 GTPAT VSSE VSSE NCH W=3.2U L=0.06U M=1 $name=/gpredrv/N00
M53 VDDCE GTPAT NET390 VDDCE PCH W=5.4U L=0.06U M=1 $name=/gpredrv/P00
M54 NET337 LGWE VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/glwge/N00
M55 VDDPE LGWE NET337 VDDCE PCH W=0.3U L=0.06U M=1 $name=/glwge/P00
M6 P7 MWL NET273 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N74/N00
M7 NET273 TIEHI VSSE VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N71/N00
M8 NET276 NET337 VSSE VSSE NCH_HVT W=0.32U L=0.07U M=1 $name=/N68/N00
M9 P3 MWL NET267 VSSE NCH_HVT W=0.15U L=0.12U M=1 $name=/N61/N00
.ENDS pe_spad_1024x16_dpMWD_HALF
****
.SUBCKT pe_spad_1024x16_dpMWDX AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AY0TRACK AY1TRACK BS0N BS1N BS2N BTP GTP GTPD GTPDE GTPMW LGWE
+  LGWET MBLIN MBL_ERR2 MGDLE MGDLS MGTPE MGTPS MWL MWL_B RBTPTERM RDTN RET
+  RRA0 RRA0_ RRA1 RRA1_ RREN TIEHI TIELO WBT XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7
+  XP8 XP9 XP10 XP11 XP12 XP13 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWDX: 56 flat devices **
XI0_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP GTP GTPD GTPDE GTP GTPMW LGWE LGWET MBL_ERR2 MBLIN MGDLE
+  MGDLS MGTPE MGTPS MWL MWL_B MBL_ERR2 P2 MBL_ERR2 MBL_ERR2 P5 P6 P7 P8 P9
+  P10 P11 P12 P13 MBL_ERR2 MBL_ERR2 MBL_ERR2 RBTPTERM RDTN RET RRA0 RRA0_
+  RRA1 RRA1_ RREN TIEHI TIELO WBT XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9
+  XP10 XP11 XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpMWD_HALF
.ENDS pe_spad_1024x16_dpMWDX
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R25 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R25: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R25
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R80 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R80: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R80
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R63 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R63: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R63
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R46 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R46: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R46
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R84 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R84: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R84
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R67 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R67: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R67
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R88 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R88: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R88
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R101 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R101: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R101
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R122 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R122: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R122
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R105 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R105: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R105
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R126 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R126: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R126
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R9 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R9: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R9
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R30 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R30: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R30
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R13 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R13: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R13
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R51 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R51: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R51
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R34 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R34: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R34
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R89 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R89: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R89
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R17 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R17: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R17
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R72 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R72: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R72
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R55 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R55: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R55
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R38 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R38: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R38
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R93 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R93: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R93
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R76 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R76: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R76
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R97 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R97: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R97
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R110 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R110: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R110
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R2 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R2: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R2
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R6 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R6: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R6
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R114 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R114: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R114
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R118 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R118: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R118
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R39 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R39: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R39
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R22 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R22: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R22
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R60 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R60: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R60
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R43 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R43: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R43
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R26 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R26: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R26
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R81 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R81: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R81
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R64 BLA BLA_ BLB BLB_ GDL MWLL PG1 PG2
+  TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 WLA1 WLA2 WLB VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R64: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED1 CORED1_ CORED_ GDL MWLL PG1 PG2 WLA1 WLA2
+  WLB VDDPE VDDCE VSSE pe_spad_1024x16_dpFLMW
.ENDS pe_spad_1024x16_dpMWL_COL_R64
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R47 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R47: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R47
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R85 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R85: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R85
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R68 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R68: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R68
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R119 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R119: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R119
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R102 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R102: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R102
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R123 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R123: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R123
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R106 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R106: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R106
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R127 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R127: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R127
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R10 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R10: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R10
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R31 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R31: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R31
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R14 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R14: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R14
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R69 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R69: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R69
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R52 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R52: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R52
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R35 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R35: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R35
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R90 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R90: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R90
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R18 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R18: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R18
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R73 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R73: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R73
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R56 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R56: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R56
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R94 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R94: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R94
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R77 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R77: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R77
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R98 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R98: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R98
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R111 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R111: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R111
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R3 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R3: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R3
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R7 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R7: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R7
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R115 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R115: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R115
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R19 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R19: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R19
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R40 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R40: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R40
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R23 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R23: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R23
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R61 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R61: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R61
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R44 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R44: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R44
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R27 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R27: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R27
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R82 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R82: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R82
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R65 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R65: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R65
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R48 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R48: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R48
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R86 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R86: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R86
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R99 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R99: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R99
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R120 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R120: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R120
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R103 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R103: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R103
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R124 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R124: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R124
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R107 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R107: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R107
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R11 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R11: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R11
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R49 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R49: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R49
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R32 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R32: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R32
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R15 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R15: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R15
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R70 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R70: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R70
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R53 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R53: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R53
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R36 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R36: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R36
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R91 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R91: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R91
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R74 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R74: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R74
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R57 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R57: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R57
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R95 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R95: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R95
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R78 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R78: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R78
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R0 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R0: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R0
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R4 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R4: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R4
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R112 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R112: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R112
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R8 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R8: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R8
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R116 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R116: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R116
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R20 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R20: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R20
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R41 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R41: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R41
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R24 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R24: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R24
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R79 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R79: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R79
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R62 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R62: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R62
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R45 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R45: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R45
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R28 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R28: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R28
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R83 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R83: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R83
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R66 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R66: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R66
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R87 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R87: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R87
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R100 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R100: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R100
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R121 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R121: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R121
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R104 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R104: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R104
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R125 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R125: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R125
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R108 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R108: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R108
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R29 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R29: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R29
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R12 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R12: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R12
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R50 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R50: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R50
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R33 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R33: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R33
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R16 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R16: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R16
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R71 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R71: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R71
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R54 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R54: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R54
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R37 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R37: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R37
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R92 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R92: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R92
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R75 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R75: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R75
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R58 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R58: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R58
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R96 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R96: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R96
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R109 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R109: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R109
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R1 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R1: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R1
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R5 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R5: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R5
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R113 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R113: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R113
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R117 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R117: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R117
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R21 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R21: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R21
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R59 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R59: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R59
****
.SUBCKT pe_spad_1024x16_dpMWL_COL_R42 BLA BLA_ BLB BLB_ GDL MWLA_0 MWLA_1
+  MWLB_0 MWLB_1 PG1 PG2 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMWL_COL_R42: 16 flat devices **
XI0_1 BLA BLA_ BLB BLB_ CORED CORED_ DIFF1 DIFF2 GDL MWLA_0 MWLB_0 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
XI0_2 BLA BLA_ BLB BLB_ CORED_6 CORED__4 DIFF1 DIFF2 GDL MWLA_1 MWLB_1 PG1 PG2
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpCCMWL
.ENDS pe_spad_1024x16_dpMWL_COL_R42
****
.SUBCKT pe_spad_1024x16_dpMWL_ROW_R BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6
+  BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17
+  BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27
+  BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37
+  BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47
+  BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57
+  BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67
+  BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76 BLA_77
+  BLA_78 BLA_79 BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86 BLA_87
+  BLA_88 BLA_89 BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96 BLA_97
+  BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105 BLA_106
+  BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114 BLA_115
+  BLA_116 BLA_117 BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123 BLA_124
+  BLA_125 BLA_126 BLA_127 BLA_128 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5
+  BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78
+  BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87
+  BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96
+  BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104
+  BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112
+  BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120
+  BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLA__128
+  BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11
+  BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21
+  BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31
+  BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41
+  BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51
+  BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61
+  BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71
+  BLB_72 BLB_73 BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81
+  BLB_82 BLB_83 BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91
+  BLB_92 BLB_93 BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101
+  BLB_102 BLB_103 BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110
+  BLB_111 BLB_112 BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119
+  BLB_120 BLB_121 BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB__0
+  BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10
+  BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19
+  BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28
+  BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37
+  BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46
+  BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55
+  BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64
+  BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73
+  BLB__74 BLB__75 BLB__76 BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82
+  BLB__83 BLB__84 BLB__85 BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91
+  BLB__92 BLB__93 BLB__94 BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100
+  BLB__101 BLB__102 BLB__103 BLB__104 BLB__105 BLB__106 BLB__107 BLB__108
+  BLB__109 BLB__110 BLB__111 BLB__112 BLB__113 BLB__114 BLB__115 BLB__116
+  BLB__117 BLB__118 BLB__119 BLB__120 BLB__121 BLB__122 BLB__123 BLB__124
+  BLB__125 BLB__126 BLB__127 BLB__128 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5
+  GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16
+  GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26
+  GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36
+  GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46
+  GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56
+  GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66
+  GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76
+  GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86
+  GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96
+  GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105
+  GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114
+  GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123
+  GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 MBL PG1_0 PG1_1 PG1_2 PG1_3 PG1_4
+  PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15
+  PG1_16 PG1_17 PG1_18 PG1_19 PG1_20 PG1_21 PG1_22 PG1_23 PG1_24 PG1_25
+  PG1_26 PG1_27 PG1_28 PG1_29 PG1_30 PG1_31 PG1_32 PG1_33 PG1_34 PG1_35
+  PG1_36 PG1_37 PG1_38 PG1_39 PG1_40 PG1_41 PG1_42 PG1_43 PG1_44 PG1_45
+  PG1_46 PG1_47 PG1_48 PG1_49 PG1_50 PG1_51 PG1_52 PG1_53 PG1_54 PG1_55
+  PG1_56 PG1_57 PG1_58 PG1_59 PG1_60 PG1_61 PG1_62 PG1_63 PG1_64 PG1_65
+  PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71 PG1_72 PG1_73 PG1_74 PG1_75
+  PG1_76 PG1_77 PG1_78 PG1_79 PG1_80 PG1_81 PG1_82 PG1_83 PG1_84 PG1_85
+  PG1_86 PG1_87 PG1_88 PG1_89 PG1_90 PG1_91 PG1_92 PG1_93 PG1_94 PG1_95
+  PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101 PG1_102 PG1_103 PG1_104 PG1_105
+  PG1_106 PG1_107 PG1_108 PG1_109 PG1_110 PG1_111 PG1_112 PG1_113 PG1_114
+  PG1_115 PG1_116 PG1_117 PG1_118 PG1_119 PG1_120 PG1_121 PG1_122 PG1_123
+  PG1_124 PG1_125 PG1_126 PG1_127 PG1_128 PG2_0 PG2_1 PG2_2 PG2_3 PG2_4 PG2_5
+  PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12 PG2_13 PG2_14 PG2_15 PG2_16
+  PG2_17 PG2_18 PG2_19 PG2_20 PG2_21 PG2_22 PG2_23 PG2_24 PG2_25 PG2_26
+  PG2_27 PG2_28 PG2_29 PG2_30 PG2_31 PG2_32 PG2_33 PG2_34 PG2_35 PG2_36
+  PG2_37 PG2_38 PG2_39 PG2_40 PG2_41 PG2_42 PG2_43 PG2_44 PG2_45 PG2_46
+  PG2_47 PG2_48 PG2_49 PG2_50 PG2_51 PG2_52 PG2_53 PG2_54 PG2_55 PG2_56
+  PG2_57 PG2_58 PG2_59 PG2_60 PG2_61 PG2_62 PG2_63 PG2_64 PG2_65 PG2_66
+  PG2_67 PG2_68 PG2_69 PG2_70 PG2_71 PG2_72 PG2_73 PG2_74 PG2_75 PG2_76
+  PG2_77 PG2_78 PG2_79 PG2_80 PG2_81 PG2_82 PG2_83 PG2_84 PG2_85 PG2_86
+  PG2_87 PG2_88 PG2_89 PG2_90 PG2_91 PG2_92 PG2_93 PG2_94 PG2_95 PG2_96
+  PG2_97 PG2_98 PG2_99 PG2_100 PG2_101 PG2_102 PG2_103 PG2_104 PG2_105
+  PG2_106 PG2_107 PG2_108 PG2_109 PG2_110 PG2_111 PG2_112 PG2_113 PG2_114
+  PG2_115 PG2_116 PG2_117 PG2_118 PG2_119 PG2_120 PG2_121 PG2_122 PG2_123
+  PG2_124 PG2_125 PG2_126 PG2_127 PG2_128 TIEHI_0 TIEHI_1 TIELO WLA WLB VDDPE
+  VDDCE VSSE
** pe_spad_1024x16_dpMWL_ROW_R: 2064 flat devices **
XI0_0 BLA_0 BLA__0 BLB__0 GDL_0 MBL PG1_0 PG2_0 TIEHI_0 TIEHI_1 TIELO WLA WLA
+  WLB WLB VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_EDGE_L
XI100_0 BLA_100 BLA__100 BLB_99 BLB__100 GDL_100 TIELO TIELO TIELO TIELO
+  PG1_100 PG2_100 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R99
XI101_0 BLA_101 BLA__101 BLB_100 BLB__101 GDL_101 TIELO TIELO TIELO TIELO
+  PG1_101 PG2_101 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R100
XI102_0 BLA_102 BLA__102 BLB_101 BLB__102 GDL_102 TIELO TIELO TIELO TIELO
+  PG1_102 PG2_102 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R101
XI103_0 BLA_103 BLA__103 BLB_102 BLB__103 GDL_103 TIELO TIELO TIELO TIELO
+  PG1_103 PG2_103 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R102
XI104_0 BLA_104 BLA__104 BLB_103 BLB__104 GDL_104 TIELO TIELO TIELO TIELO
+  PG1_104 PG2_104 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R103
XI105_0 BLA_105 BLA__105 BLB_104 BLB__105 GDL_105 TIELO TIELO TIELO TIELO
+  PG1_105 PG2_105 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R104
XI106_0 BLA_106 BLA__106 BLB_105 BLB__106 GDL_106 TIELO TIELO TIELO TIELO
+  PG1_106 PG2_106 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R105
XI107_0 BLA_107 BLA__107 BLB_106 BLB__107 GDL_107 TIELO TIELO TIELO TIELO
+  PG1_107 PG2_107 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R106
XI108_0 BLA_108 BLA__108 BLB_107 BLB__108 GDL_108 TIELO TIELO TIELO TIELO
+  PG1_108 PG2_108 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R107
XI109_0 BLA_109 BLA__109 BLB_108 BLB__109 GDL_109 TIELO TIELO TIELO TIELO
+  PG1_109 PG2_109 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R108
XI10_0 BLA_10 BLA__10 BLB_9 BLB__10 GDL_10 WLA WLA WLB WLB PG1_10 PG2_10
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R9
XI110_0 BLA_110 BLA__110 BLB_109 BLB__110 GDL_110 TIELO TIELO TIELO TIELO
+  PG1_110 PG2_110 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R109
XI111_0 BLA_111 BLA__111 BLB_110 BLB__111 GDL_111 TIELO TIELO TIELO TIELO
+  PG1_111 PG2_111 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R110
XI112_0 BLA_112 BLA__112 BLB_111 BLB__112 GDL_112 TIELO TIELO TIELO TIELO
+  PG1_112 PG2_112 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R111
XI113_0 BLA_113 BLA__113 BLB_112 BLB__113 GDL_113 TIELO TIELO TIELO TIELO
+  PG1_113 PG2_113 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R112
XI114_0 BLA_114 BLA__114 BLB_113 BLB__114 GDL_114 TIELO TIELO TIELO TIELO
+  PG1_114 PG2_114 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R113
XI115_0 BLA_115 BLA__115 BLB_114 BLB__115 GDL_115 TIELO TIELO TIELO TIELO
+  PG1_115 PG2_115 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R114
XI116_0 BLA_116 BLA__116 BLB_115 BLB__116 GDL_116 TIELO TIELO TIELO TIELO
+  PG1_116 PG2_116 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R115
XI117_0 BLA_117 BLA__117 BLB_116 BLB__117 GDL_117 TIELO TIELO TIELO TIELO
+  PG1_117 PG2_117 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R116
XI118_0 BLA_118 BLA__118 BLB_117 BLB__118 GDL_118 TIELO TIELO TIELO TIELO
+  PG1_118 PG2_118 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R117
XI119_0 BLA_119 BLA__119 BLB_118 BLB__119 GDL_119 TIELO TIELO TIELO TIELO
+  PG1_119 PG2_119 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R118
XI11_0 BLA_11 BLA__11 BLB_10 BLB__11 GDL_11 WLA WLA WLB WLB PG1_11 PG2_11
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R10
XI120_0 BLA_120 BLA__120 BLB_119 BLB__120 GDL_120 TIELO TIELO TIELO TIELO
+  PG1_120 PG2_120 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R119
XI121_0 BLA_121 BLA__121 BLB_120 BLB__121 GDL_121 TIELO TIELO TIELO TIELO
+  PG1_121 PG2_121 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R120
XI122_0 BLA_122 BLA__122 BLB_121 BLB__122 GDL_122 TIELO TIELO TIELO TIELO
+  PG1_122 PG2_122 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R121
XI123_0 BLA_123 BLA__123 BLB_122 BLB__123 GDL_123 TIELO TIELO TIELO TIELO
+  PG1_123 PG2_123 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R122
XI124_0 BLA_124 BLA__124 BLB_123 BLB__124 GDL_124 TIELO TIELO TIELO TIELO
+  PG1_124 PG2_124 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R123
XI125_0 BLA_125 BLA__125 BLB_124 BLB__125 GDL_125 TIELO TIELO TIELO TIELO
+  PG1_125 PG2_125 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R124
XI126_0 BLA_126 BLA__126 BLB_125 BLB__126 GDL_126 TIELO TIELO TIELO TIELO
+  PG1_126 PG2_126 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R125
XI127_0 BLA_127 BLA__127 BLB_126 BLB__127 GDL_127 TIELO TIELO TIELO TIELO
+  PG1_127 PG2_127 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R126
XI128_0 BLA_128 BLA__128 BLB_127 BLB__128 GDL_128 TIELO TIELO TIELO TIELO
+  PG1_128 PG2_128 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R127
XI12_0 BLA_12 BLA__12 BLB_11 BLB__12 GDL_12 WLA WLA WLB WLB PG1_12 PG2_12
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R11
XI13_0 BLA_13 BLA__13 BLB_12 BLB__13 GDL_13 WLA WLA WLB WLB PG1_13 PG2_13
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R12
XI14_0 BLA_14 BLA__14 BLB_13 BLB__14 GDL_14 WLA WLA WLB WLB PG1_14 PG2_14
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R13
XI15_0 BLA_15 BLA__15 BLB_14 BLB__15 GDL_15 WLA WLA WLB WLB PG1_15 PG2_15
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R14
XI16_0 BLA_16 BLA__16 BLB_15 BLB__16 GDL_16 WLA WLA WLB WLB PG1_16 PG2_16
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R15
XI17_0 BLA_17 BLA__17 BLB_16 BLB__17 GDL_17 WLA WLA WLB WLB PG1_17 PG2_17
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R16
XI18_0 BLA_18 BLA__18 BLB_17 BLB__18 GDL_18 WLA WLA WLB WLB PG1_18 PG2_18
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R17
XI19_0 BLA_19 BLA__19 BLB_18 BLB__19 GDL_19 WLA WLA WLB WLB PG1_19 PG2_19
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R18
XI1_0 BLA_1 BLA__1 BLB_0 BLB__1 GDL_1 WLA WLA WLB WLB PG1_1 PG2_1 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R0
XI20_0 BLA_20 BLA__20 BLB_19 BLB__20 GDL_20 WLA WLA WLB WLB PG1_20 PG2_20
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R19
XI21_0 BLA_21 BLA__21 BLB_20 BLB__21 GDL_21 WLA WLA WLB WLB PG1_21 PG2_21
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R20
XI22_0 BLA_22 BLA__22 BLB_21 BLB__22 GDL_22 WLA WLA WLB WLB PG1_22 PG2_22
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R21
XI23_0 BLA_23 BLA__23 BLB_22 BLB__23 GDL_23 WLA WLA WLB WLB PG1_23 PG2_23
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R22
XI24_0 BLA_24 BLA__24 BLB_23 BLB__24 GDL_24 WLA WLA WLB WLB PG1_24 PG2_24
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R23
XI25_0 BLA_25 BLA__25 BLB_24 BLB__25 GDL_25 WLA WLA WLB WLB PG1_25 PG2_25
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R24
XI26_0 BLA_26 BLA__26 BLB_25 BLB__26 GDL_26 WLA WLA WLB WLB PG1_26 PG2_26
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R25
XI27_0 BLA_27 BLA__27 BLB_26 BLB__27 GDL_27 WLA WLA WLB WLB PG1_27 PG2_27
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R26
XI28_0 BLA_28 BLA__28 BLB_27 BLB__28 GDL_28 WLA WLA WLB WLB PG1_28 PG2_28
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R27
XI29_0 BLA_29 BLA__29 BLB_28 BLB__29 GDL_29 WLA WLA WLB WLB PG1_29 PG2_29
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R28
XI2_0 BLA_2 BLA__2 BLB_1 BLB__2 GDL_2 WLA WLA WLB WLB PG1_2 PG2_2 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R1
XI30_0 BLA_30 BLA__30 BLB_29 BLB__30 GDL_30 WLA WLA WLB WLB PG1_30 PG2_30
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R29
XI31_0 BLA_31 BLA__31 BLB_30 BLB__31 GDL_31 WLA WLA WLB WLB PG1_31 PG2_31
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R30
XI32_0 BLA_32 BLA__32 BLB_31 BLB__32 GDL_32 WLA WLA WLB WLB PG1_32 PG2_32
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R31
XI33_0 BLA_33 BLA__33 BLB_32 BLB__33 GDL_33 WLA WLA WLB WLB PG1_33 PG2_33
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R32
XI34_0 BLA_34 BLA__34 BLB_33 BLB__34 GDL_34 WLA WLA WLB WLB PG1_34 PG2_34
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R33
XI35_0 BLA_35 BLA__35 BLB_34 BLB__35 GDL_35 WLA WLA WLB WLB PG1_35 PG2_35
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R34
XI36_0 BLA_36 BLA__36 BLB_35 BLB__36 GDL_36 WLA WLA WLB WLB PG1_36 PG2_36
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R35
XI37_0 BLA_37 BLA__37 BLB_36 BLB__37 GDL_37 WLA WLA WLB WLB PG1_37 PG2_37
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R36
XI38_0 BLA_38 BLA__38 BLB_37 BLB__38 GDL_38 WLA WLA WLB WLB PG1_38 PG2_38
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R37
XI39_0 BLA_39 BLA__39 BLB_38 BLB__39 GDL_39 WLA WLA WLB WLB PG1_39 PG2_39
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R38
XI3_0 BLA_3 BLA__3 BLB_2 BLB__3 GDL_3 WLA WLA WLB WLB PG1_3 PG2_3 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R2
XI40_0 BLA_40 BLA__40 BLB_39 BLB__40 GDL_40 WLA WLA WLB WLB PG1_40 PG2_40
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R39
XI41_0 BLA_41 BLA__41 BLB_40 BLB__41 GDL_41 WLA WLA WLB WLB PG1_41 PG2_41
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R40
XI42_0 BLA_42 BLA__42 BLB_41 BLB__42 GDL_42 WLA WLA WLB WLB PG1_42 PG2_42
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R41
XI43_0 BLA_43 BLA__43 BLB_42 BLB__43 GDL_43 WLA WLA WLB WLB PG1_43 PG2_43
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R42
XI44_0 BLA_44 BLA__44 BLB_43 BLB__44 GDL_44 WLA WLA WLB WLB PG1_44 PG2_44
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R43
XI45_0 BLA_45 BLA__45 BLB_44 BLB__45 GDL_45 WLA WLA WLB WLB PG1_45 PG2_45
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R44
XI46_0 BLA_46 BLA__46 BLB_45 BLB__46 GDL_46 WLA WLA WLB WLB PG1_46 PG2_46
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R45
XI47_0 BLA_47 BLA__47 BLB_46 BLB__47 GDL_47 WLA WLA WLB WLB PG1_47 PG2_47
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R46
XI48_0 BLA_48 BLA__48 BLB_47 BLB__48 GDL_48 WLA WLA WLB WLB PG1_48 PG2_48
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R47
XI49_0 BLA_49 BLA__49 BLB_48 BLB__49 GDL_49 WLA WLA WLB WLB PG1_49 PG2_49
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R48
XI4_0 BLA_4 BLA__4 BLB_3 BLB__4 GDL_4 WLA WLA WLB WLB PG1_4 PG2_4 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R3
XI50_0 BLA_50 BLA__50 BLB_49 BLB__50 GDL_50 WLA WLA WLB WLB PG1_50 PG2_50
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R49
XI51_0 BLA_51 BLA__51 BLB_50 BLB__51 GDL_51 WLA WLA WLB WLB PG1_51 PG2_51
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R50
XI52_0 BLA_52 BLA__52 BLB_51 BLB__52 GDL_52 WLA WLA WLB WLB PG1_52 PG2_52
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R51
XI53_0 BLA_53 BLA__53 BLB_52 BLB__53 GDL_53 WLA WLA WLB WLB PG1_53 PG2_53
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R52
XI54_0 BLA_54 BLA__54 BLB_53 BLB__54 GDL_54 WLA WLA WLB WLB PG1_54 PG2_54
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R53
XI55_0 BLA_55 BLA__55 BLB_54 BLB__55 GDL_55 WLA WLA WLB WLB PG1_55 PG2_55
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R54
XI56_0 BLA_56 BLA__56 BLB_55 BLB__56 GDL_56 WLA WLA WLB WLB PG1_56 PG2_56
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R55
XI57_0 BLA_57 BLA__57 BLB_56 BLB__57 GDL_57 WLA WLA WLB WLB PG1_57 PG2_57
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R56
XI58_0 BLA_58 BLA__58 BLB_57 BLB__58 GDL_58 WLA WLA WLB WLB PG1_58 PG2_58
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R57
XI59_0 BLA_59 BLA__59 BLB_58 BLB__59 GDL_59 WLA WLA WLB WLB PG1_59 PG2_59
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R58
XI5_0 BLA_5 BLA__5 BLB_4 BLB__5 GDL_5 WLA WLA WLB WLB PG1_5 PG2_5 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R4
XI60_0 BLA_60 BLA__60 BLB_59 BLB__60 GDL_60 WLA WLA WLB WLB PG1_60 PG2_60
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R59
XI61_0 BLA_61 BLA__61 BLB_60 BLB__61 GDL_61 WLA WLA WLB WLB PG1_61 PG2_61
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R60
XI62_0 BLA_62 BLA__62 BLB_61 BLB__62 GDL_62 WLA WLA WLB WLB PG1_62 PG2_62
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R61
XI63_0 BLA_63 BLA__63 BLB_62 BLB__63 GDL_63 WLA WLA WLB WLB PG1_63 PG2_63
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R62
XI64_0 BLA_64 BLA__64 BLB_63 BLB__64 GDL_64 WLA WLA WLB WLB PG1_64 PG2_64
+  TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R63
XI65_0 BLA_65 BLA__65 BLB_64 BLB__65 GDL_65 WLB PG1_65 PG2_65 TIEHI_0 TIEHI_1
+  TIELO TIELO WLA TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R64
XI66_0 BLA_66 BLA__66 BLB_65 BLB__66 GDL_66 TIELO TIELO TIELO TIELO PG1_66
+  PG2_66 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R65
XI67_0 BLA_67 BLA__67 BLB_66 BLB__67 GDL_67 TIELO TIELO TIELO TIELO PG1_67
+  PG2_67 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R66
XI68_0 BLA_68 BLA__68 BLB_67 BLB__68 GDL_68 TIELO TIELO TIELO TIELO PG1_68
+  PG2_68 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R67
XI69_0 BLA_69 BLA__69 BLB_68 BLB__69 GDL_69 TIELO TIELO TIELO TIELO PG1_69
+  PG2_69 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R68
XI6_0 BLA_6 BLA__6 BLB_5 BLB__6 GDL_6 WLA WLA WLB WLB PG1_6 PG2_6 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R5
XI70_0 BLA_70 BLA__70 BLB_69 BLB__70 GDL_70 TIELO TIELO TIELO TIELO PG1_70
+  PG2_70 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R69
XI71_0 BLA_71 BLA__71 BLB_70 BLB__71 GDL_71 TIELO TIELO TIELO TIELO PG1_71
+  PG2_71 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R70
XI72_0 BLA_72 BLA__72 BLB_71 BLB__72 GDL_72 TIELO TIELO TIELO TIELO PG1_72
+  PG2_72 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R71
XI73_0 BLA_73 BLA__73 BLB_72 BLB__73 GDL_73 TIELO TIELO TIELO TIELO PG1_73
+  PG2_73 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R72
XI74_0 BLA_74 BLA__74 BLB_73 BLB__74 GDL_74 TIELO TIELO TIELO TIELO PG1_74
+  PG2_74 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R73
XI75_0 BLA_75 BLA__75 BLB_74 BLB__75 GDL_75 TIELO TIELO TIELO TIELO PG1_75
+  PG2_75 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R74
XI76_0 BLA_76 BLA__76 BLB_75 BLB__76 GDL_76 TIELO TIELO TIELO TIELO PG1_76
+  PG2_76 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R75
XI77_0 BLA_77 BLA__77 BLB_76 BLB__77 GDL_77 TIELO TIELO TIELO TIELO PG1_77
+  PG2_77 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R76
XI78_0 BLA_78 BLA__78 BLB_77 BLB__78 GDL_78 TIELO TIELO TIELO TIELO PG1_78
+  PG2_78 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R77
XI79_0 BLA_79 BLA__79 BLB_78 BLB__79 GDL_79 TIELO TIELO TIELO TIELO PG1_79
+  PG2_79 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R78
XI7_0 BLA_7 BLA__7 BLB_6 BLB__7 GDL_7 WLA WLA WLB WLB PG1_7 PG2_7 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R6
XI80_0 BLA_80 BLA__80 BLB_79 BLB__80 GDL_80 TIELO TIELO TIELO TIELO PG1_80
+  PG2_80 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R79
XI81_0 BLA_81 BLA__81 BLB_80 BLB__81 GDL_81 TIELO TIELO TIELO TIELO PG1_81
+  PG2_81 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R80
XI82_0 BLA_82 BLA__82 BLB_81 BLB__82 GDL_82 TIELO TIELO TIELO TIELO PG1_82
+  PG2_82 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R81
XI83_0 BLA_83 BLA__83 BLB_82 BLB__83 GDL_83 TIELO TIELO TIELO TIELO PG1_83
+  PG2_83 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R82
XI84_0 BLA_84 BLA__84 BLB_83 BLB__84 GDL_84 TIELO TIELO TIELO TIELO PG1_84
+  PG2_84 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R83
XI85_0 BLA_85 BLA__85 BLB_84 BLB__85 GDL_85 TIELO TIELO TIELO TIELO PG1_85
+  PG2_85 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R84
XI86_0 BLA_86 BLA__86 BLB_85 BLB__86 GDL_86 TIELO TIELO TIELO TIELO PG1_86
+  PG2_86 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R85
XI87_0 BLA_87 BLA__87 BLB_86 BLB__87 GDL_87 TIELO TIELO TIELO TIELO PG1_87
+  PG2_87 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R86
XI88_0 BLA_88 BLA__88 BLB_87 BLB__88 GDL_88 TIELO TIELO TIELO TIELO PG1_88
+  PG2_88 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R87
XI89_0 BLA_89 BLA__89 BLB_88 BLB__89 GDL_89 TIELO TIELO TIELO TIELO PG1_89
+  PG2_89 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R88
XI8_0 BLA_8 BLA__8 BLB_7 BLB__8 GDL_8 WLA WLA WLB WLB PG1_8 PG2_8 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R7
XI90_0 BLA_90 BLA__90 BLB_89 BLB__90 GDL_90 TIELO TIELO TIELO TIELO PG1_90
+  PG2_90 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R89
XI91_0 BLA_91 BLA__91 BLB_90 BLB__91 GDL_91 TIELO TIELO TIELO TIELO PG1_91
+  PG2_91 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R90
XI92_0 BLA_92 BLA__92 BLB_91 BLB__92 GDL_92 TIELO TIELO TIELO TIELO PG1_92
+  PG2_92 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R91
XI93_0 BLA_93 BLA__93 BLB_92 BLB__93 GDL_93 TIELO TIELO TIELO TIELO PG1_93
+  PG2_93 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R92
XI94_0 BLA_94 BLA__94 BLB_93 BLB__94 GDL_94 TIELO TIELO TIELO TIELO PG1_94
+  PG2_94 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R93
XI95_0 BLA_95 BLA__95 BLB_94 BLB__95 GDL_95 TIELO TIELO TIELO TIELO PG1_95
+  PG2_95 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R94
XI96_0 BLA_96 BLA__96 BLB_95 BLB__96 GDL_96 TIELO TIELO TIELO TIELO PG1_96
+  PG2_96 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R95
XI97_0 BLA_97 BLA__97 BLB_96 BLB__97 GDL_97 TIELO TIELO TIELO TIELO PG1_97
+  PG2_97 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R96
XI98_0 BLA_98 BLA__98 BLB_97 BLB__98 GDL_98 TIELO TIELO TIELO TIELO PG1_98
+  PG2_98 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R97
XI99_0 BLA_99 BLA__99 BLB_98 BLB__99 GDL_99 TIELO TIELO TIELO TIELO PG1_99
+  PG2_99 TIEHI_0 TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_COL_R98
XI9_0 BLA_9 BLA__9 BLB_8 BLB__9 GDL_9 WLA WLA WLB WLB PG1_9 PG2_9 TIEHI_0
+  TIEHI_1 TIELO TIELO VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_COL_R8
.ENDS pe_spad_1024x16_dpMWL_ROW_R
****
.SUBCKT pe_spad_1024x16_dpMODEL_ROW AX0TRACK_0 AX0TRACK_1 AX1TRACK_0
+  AX1TRACK_1 AX2TRACK_0 AX2TRACK_1 AX3TRACK_0 AX3TRACK_1 AX4TRACK_0
+  AX4TRACK_1 AX5TRACK_0 AX5TRACK_1 AY0TRACK_0 AY0TRACK_1 AY1TRACK_0
+  AY1TRACK_1 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9
+  BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17 BLA_18 BLA_19
+  BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27 BLA_28 BLA_29
+  BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39
+  BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA_48 BLA_49
+  BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57 BLA_58 BLA_59
+  BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69
+  BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76 BLA_77 BLA_78 BLA_79
+  BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86 BLA_87 BLA_88 BLA_89
+  BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96 BLA_97 BLA_98 BLA_99
+  BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105 BLA_106 BLA_107 BLA_108
+  BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114 BLA_115 BLA_116 BLA_117
+  BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123 BLA_124 BLA_125 BLA_126
+  BLA_127 BLA_128 BLA_129 BLA_130 BLA_131 BLA_132 BLA_133 BLA_134 BLA_135
+  BLA_136 BLA_137 BLA_138 BLA_139 BLA_140 BLA_141 BLA_142 BLA_143 BLA_144
+  BLA_145 BLA_146 BLA_147 BLA_148 BLA_149 BLA_150 BLA_151 BLA_152 BLA_153
+  BLA_154 BLA_155 BLA_156 BLA_157 BLA_158 BLA_159 BLA_160 BLA_161 BLA_162
+  BLA_163 BLA_164 BLA_165 BLA_166 BLA_167 BLA_168 BLA_169 BLA_170 BLA_171
+  BLA_172 BLA_173 BLA_174 BLA_175 BLA_176 BLA_177 BLA_178 BLA_179 BLA_180
+  BLA_181 BLA_182 BLA_183 BLA_184 BLA_185 BLA_186 BLA_187 BLA_188 BLA_189
+  BLA_190 BLA_191 BLA_192 BLA_193 BLA_194 BLA_195 BLA_196 BLA_197 BLA_198
+  BLA_199 BLA_200 BLA_201 BLA_202 BLA_203 BLA_204 BLA_205 BLA_206 BLA_207
+  BLA_208 BLA_209 BLA_210 BLA_211 BLA_212 BLA_213 BLA_214 BLA_215 BLA_216
+  BLA_217 BLA_218 BLA_219 BLA_220 BLA_221 BLA_222 BLA_223 BLA_224 BLA_225
+  BLA_226 BLA_227 BLA_228 BLA_229 BLA_230 BLA_231 BLA_232 BLA_233 BLA_234
+  BLA_235 BLA_236 BLA_237 BLA_238 BLA_239 BLA_240 BLA_241 BLA_242 BLA_243
+  BLA_244 BLA_245 BLA_246 BLA_247 BLA_248 BLA_249 BLA_250 BLA_251 BLA_252
+  BLA_253 BLA_254 BLA_255 BLA_256 BLA_257 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23
+  BLA__24 BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32
+  BLA__33 BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41
+  BLA__42 BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50
+  BLA__51 BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59
+  BLA__60 BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68
+  BLA__69 BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77
+  BLA__78 BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86
+  BLA__87 BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95
+  BLA__96 BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103
+  BLA__104 BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111
+  BLA__112 BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119
+  BLA__120 BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127
+  BLA__128 BLA__129 BLA__130 BLA__131 BLA__132 BLA__133 BLA__134 BLA__135
+  BLA__136 BLA__137 BLA__138 BLA__139 BLA__140 BLA__141 BLA__142 BLA__143
+  BLA__144 BLA__145 BLA__146 BLA__147 BLA__148 BLA__149 BLA__150 BLA__151
+  BLA__152 BLA__153 BLA__154 BLA__155 BLA__156 BLA__157 BLA__158 BLA__159
+  BLA__160 BLA__161 BLA__162 BLA__163 BLA__164 BLA__165 BLA__166 BLA__167
+  BLA__168 BLA__169 BLA__170 BLA__171 BLA__172 BLA__173 BLA__174 BLA__175
+  BLA__176 BLA__177 BLA__178 BLA__179 BLA__180 BLA__181 BLA__182 BLA__183
+  BLA__184 BLA__185 BLA__186 BLA__187 BLA__188 BLA__189 BLA__190 BLA__191
+  BLA__192 BLA__193 BLA__194 BLA__195 BLA__196 BLA__197 BLA__198 BLA__199
+  BLA__200 BLA__201 BLA__202 BLA__203 BLA__204 BLA__205 BLA__206 BLA__207
+  BLA__208 BLA__209 BLA__210 BLA__211 BLA__212 BLA__213 BLA__214 BLA__215
+  BLA__216 BLA__217 BLA__218 BLA__219 BLA__220 BLA__221 BLA__222 BLA__223
+  BLA__224 BLA__225 BLA__226 BLA__227 BLA__228 BLA__229 BLA__230 BLA__231
+  BLA__232 BLA__233 BLA__234 BLA__235 BLA__236 BLA__237 BLA__238 BLA__239
+  BLA__240 BLA__241 BLA__242 BLA__243 BLA__244 BLA__245 BLA__246 BLA__247
+  BLA__248 BLA__249 BLA__250 BLA__251 BLA__252 BLA__253 BLA__254 BLA__255
+  BLA__256 BLA__257 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8
+  BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19
+  BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29
+  BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39
+  BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49
+  BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59
+  BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69
+  BLB_70 BLB_71 BLB_72 BLB_73 BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79
+  BLB_80 BLB_81 BLB_82 BLB_83 BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89
+  BLB_90 BLB_91 BLB_92 BLB_93 BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99
+  BLB_100 BLB_101 BLB_102 BLB_103 BLB_104 BLB_105 BLB_106 BLB_107 BLB_108
+  BLB_109 BLB_110 BLB_111 BLB_112 BLB_113 BLB_114 BLB_115 BLB_116 BLB_117
+  BLB_118 BLB_119 BLB_120 BLB_121 BLB_122 BLB_123 BLB_124 BLB_125 BLB_126
+  BLB_127 BLB_128 BLB_129 BLB_130 BLB_131 BLB_132 BLB_133 BLB_134 BLB_135
+  BLB_136 BLB_137 BLB_138 BLB_139 BLB_140 BLB_141 BLB_142 BLB_143 BLB_144
+  BLB_145 BLB_146 BLB_147 BLB_148 BLB_149 BLB_150 BLB_151 BLB_152 BLB_153
+  BLB_154 BLB_155 BLB_156 BLB_157 BLB_158 BLB_159 BLB_160 BLB_161 BLB_162
+  BLB_163 BLB_164 BLB_165 BLB_166 BLB_167 BLB_168 BLB_169 BLB_170 BLB_171
+  BLB_172 BLB_173 BLB_174 BLB_175 BLB_176 BLB_177 BLB_178 BLB_179 BLB_180
+  BLB_181 BLB_182 BLB_183 BLB_184 BLB_185 BLB_186 BLB_187 BLB_188 BLB_189
+  BLB_190 BLB_191 BLB_192 BLB_193 BLB_194 BLB_195 BLB_196 BLB_197 BLB_198
+  BLB_199 BLB_200 BLB_201 BLB_202 BLB_203 BLB_204 BLB_205 BLB_206 BLB_207
+  BLB_208 BLB_209 BLB_210 BLB_211 BLB_212 BLB_213 BLB_214 BLB_215 BLB_216
+  BLB_217 BLB_218 BLB_219 BLB_220 BLB_221 BLB_222 BLB_223 BLB_224 BLB_225
+  BLB_226 BLB_227 BLB_228 BLB_229 BLB_230 BLB_231 BLB_232 BLB_233 BLB_234
+  BLB_235 BLB_236 BLB_237 BLB_238 BLB_239 BLB_240 BLB_241 BLB_242 BLB_243
+  BLB_244 BLB_245 BLB_246 BLB_247 BLB_248 BLB_249 BLB_250 BLB_251 BLB_252
+  BLB_253 BLB_254 BLB_255 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6
+  BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14 BLB__15
+  BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23 BLB__24
+  BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32 BLB__33
+  BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41 BLB__42
+  BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50 BLB__51
+  BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59 BLB__60
+  BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68 BLB__69
+  BLB__70 BLB__71 BLB__72 BLB__73 BLB__74 BLB__75 BLB__76 BLB__77 BLB__78
+  BLB__79 BLB__80 BLB__81 BLB__82 BLB__83 BLB__84 BLB__85 BLB__86 BLB__87
+  BLB__88 BLB__89 BLB__90 BLB__91 BLB__92 BLB__93 BLB__94 BLB__95 BLB__96
+  BLB__97 BLB__98 BLB__99 BLB__100 BLB__101 BLB__102 BLB__103 BLB__104
+  BLB__105 BLB__106 BLB__107 BLB__108 BLB__109 BLB__110 BLB__111 BLB__112
+  BLB__113 BLB__114 BLB__115 BLB__116 BLB__117 BLB__118 BLB__119 BLB__120
+  BLB__121 BLB__122 BLB__123 BLB__124 BLB__125 BLB__126 BLB__127 BLB__128
+  BLB__129 BLB__130 BLB__131 BLB__132 BLB__133 BLB__134 BLB__135 BLB__136
+  BLB__137 BLB__138 BLB__139 BLB__140 BLB__141 BLB__142 BLB__143 BLB__144
+  BLB__145 BLB__146 BLB__147 BLB__148 BLB__149 BLB__150 BLB__151 BLB__152
+  BLB__153 BLB__154 BLB__155 BLB__156 BLB__157 BLB__158 BLB__159 BLB__160
+  BLB__161 BLB__162 BLB__163 BLB__164 BLB__165 BLB__166 BLB__167 BLB__168
+  BLB__169 BLB__170 BLB__171 BLB__172 BLB__173 BLB__174 BLB__175 BLB__176
+  BLB__177 BLB__178 BLB__179 BLB__180 BLB__181 BLB__182 BLB__183 BLB__184
+  BLB__185 BLB__186 BLB__187 BLB__188 BLB__189 BLB__190 BLB__191 BLB__192
+  BLB__193 BLB__194 BLB__195 BLB__196 BLB__197 BLB__198 BLB__199 BLB__200
+  BLB__201 BLB__202 BLB__203 BLB__204 BLB__205 BLB__206 BLB__207 BLB__208
+  BLB__209 BLB__210 BLB__211 BLB__212 BLB__213 BLB__214 BLB__215 BLB__216
+  BLB__217 BLB__218 BLB__219 BLB__220 BLB__221 BLB__222 BLB__223 BLB__224
+  BLB__225 BLB__226 BLB__227 BLB__228 BLB__229 BLB__230 BLB__231 BLB__232
+  BLB__233 BLB__234 BLB__235 BLB__236 BLB__237 BLB__238 BLB__239 BLB__240
+  BLB__241 BLB__242 BLB__243 BLB__244 BLB__245 BLB__246 BLB__247 BLB__248
+  BLB__249 BLB__250 BLB__251 BLB__252 BLB__253 BLB__254 BLB__255 BLB__256
+  BLB__257 BS0N_0 BS0N_1 BS1N_0 BS1N_1 BS2N_0 BS2N_1 BTP_0 BTP_1 GDL_0 GDL_1
+  GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53
+  GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63
+  GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73
+  GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83
+  GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93
+  GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103
+  GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112
+  GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121
+  GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL_128 GDL_129 GDL_130
+  GDL_131 GDL_132 GDL_133 GDL_134 GDL_135 GDL_136 GDL_137 GDL_138 GDL_139
+  GDL_140 GDL_141 GDL_142 GDL_143 GDL_144 GDL_145 GDL_146 GDL_147 GDL_148
+  GDL_149 GDL_150 GDL_151 GDL_152 GDL_153 GDL_154 GDL_155 GDL_156 GDL_157
+  GDL_158 GDL_159 GDL_160 GDL_161 GDL_162 GDL_163 GDL_164 GDL_165 GDL_166
+  GDL_167 GDL_168 GDL_169 GDL_170 GDL_171 GDL_172 GDL_173 GDL_174 GDL_175
+  GDL_176 GDL_177 GDL_178 GDL_179 GDL_180 GDL_181 GDL_182 GDL_183 GDL_184
+  GDL_185 GDL_186 GDL_187 GDL_188 GDL_189 GDL_190 GDL_191 GDL_192 GDL_193
+  GDL_194 GDL_195 GDL_196 GDL_197 GDL_198 GDL_199 GDL_200 GDL_201 GDL_202
+  GDL_203 GDL_204 GDL_205 GDL_206 GDL_207 GDL_208 GDL_209 GDL_210 GDL_211
+  GDL_212 GDL_213 GDL_214 GDL_215 GDL_216 GDL_217 GDL_218 GDL_219 GDL_220
+  GDL_221 GDL_222 GDL_223 GDL_224 GDL_225 GDL_226 GDL_227 GDL_228 GDL_229
+  GDL_230 GDL_231 GDL_232 GDL_233 GDL_234 GDL_235 GDL_236 GDL_237 GDL_238
+  GDL_239 GDL_240 GDL_241 GDL_242 GDL_243 GDL_244 GDL_245 GDL_246 GDL_247
+  GDL_248 GDL_249 GDL_250 GDL_251 GDL_252 GDL_253 GDL_254 GDL_255 GDL_256
+  GDL_257 GTPDE_0 GTPDE_1 GTPD_0 GTPD_1 GTPMW_0 GTPMW_1 GTP_0 GTP_1 LGWET_0
+  LGWET_1 LGWE_0 LGWE_1 MBL_0 MBL_1 MBL_ERR2_0 MBL_ERR2_1 MGDLE_0 MGDLE_1
+  MGDLS_0 MGDLS_1 MGTPE_0 MGTPE_1 MGTPS_0 MGTPS_1 PG1_0 PG1_1 PG1_2 PG1_3
+  PG1_4 PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14
+  PG1_15 PG1_16 PG1_17 PG1_18 PG1_19 PG1_20 PG1_21 PG1_22 PG1_23 PG1_24
+  PG1_25 PG1_26 PG1_27 PG1_28 PG1_29 PG1_30 PG1_31 PG1_32 PG1_33 PG1_34
+  PG1_35 PG1_36 PG1_37 PG1_38 PG1_39 PG1_40 PG1_41 PG1_42 PG1_43 PG1_44
+  PG1_45 PG1_46 PG1_47 PG1_48 PG1_49 PG1_50 PG1_51 PG1_52 PG1_53 PG1_54
+  PG1_55 PG1_56 PG1_57 PG1_58 PG1_59 PG1_60 PG1_61 PG1_62 PG1_63 PG1_64
+  PG1_65 PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71 PG1_72 PG1_73 PG1_74
+  PG1_75 PG1_76 PG1_77 PG1_78 PG1_79 PG1_80 PG1_81 PG1_82 PG1_83 PG1_84
+  PG1_85 PG1_86 PG1_87 PG1_88 PG1_89 PG1_90 PG1_91 PG1_92 PG1_93 PG1_94
+  PG1_95 PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101 PG1_102 PG1_103 PG1_104
+  PG1_105 PG1_106 PG1_107 PG1_108 PG1_109 PG1_110 PG1_111 PG1_112 PG1_113
+  PG1_114 PG1_115 PG1_116 PG1_117 PG1_118 PG1_119 PG1_120 PG1_121 PG1_122
+  PG1_123 PG1_124 PG1_125 PG1_126 PG1_127 PG1_128 PG1_129 PG1_130 PG1_131
+  PG1_132 PG1_133 PG1_134 PG1_135 PG1_136 PG1_137 PG1_138 PG1_139 PG1_140
+  PG1_141 PG1_142 PG1_143 PG1_144 PG1_145 PG1_146 PG1_147 PG1_148 PG1_149
+  PG1_150 PG1_151 PG1_152 PG1_153 PG1_154 PG1_155 PG1_156 PG1_157 PG1_158
+  PG1_159 PG1_160 PG1_161 PG1_162 PG1_163 PG1_164 PG1_165 PG1_166 PG1_167
+  PG1_168 PG1_169 PG1_170 PG1_171 PG1_172 PG1_173 PG1_174 PG1_175 PG1_176
+  PG1_177 PG1_178 PG1_179 PG1_180 PG1_181 PG1_182 PG1_183 PG1_184 PG1_185
+  PG1_186 PG1_187 PG1_188 PG1_189 PG1_190 PG1_191 PG1_192 PG1_193 PG1_194
+  PG1_195 PG1_196 PG1_197 PG1_198 PG1_199 PG1_200 PG1_201 PG1_202 PG1_203
+  PG1_204 PG1_205 PG1_206 PG1_207 PG1_208 PG1_209 PG1_210 PG1_211 PG1_212
+  PG1_213 PG1_214 PG1_215 PG1_216 PG1_217 PG1_218 PG1_219 PG1_220 PG1_221
+  PG1_222 PG1_223 PG1_224 PG1_225 PG1_226 PG1_227 PG1_228 PG1_229 PG1_230
+  PG1_231 PG1_232 PG1_233 PG1_234 PG1_235 PG1_236 PG1_237 PG1_238 PG1_239
+  PG1_240 PG1_241 PG1_242 PG1_243 PG1_244 PG1_245 PG1_246 PG1_247 PG1_248
+  PG1_249 PG1_250 PG1_251 PG1_252 PG1_253 PG1_254 PG1_255 PG1_256 PG1_257
+  PG2_0 PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11
+  PG2_12 PG2_13 PG2_14 PG2_15 PG2_16 PG2_17 PG2_18 PG2_19 PG2_20 PG2_21
+  PG2_22 PG2_23 PG2_24 PG2_25 PG2_26 PG2_27 PG2_28 PG2_29 PG2_30 PG2_31
+  PG2_32 PG2_33 PG2_34 PG2_35 PG2_36 PG2_37 PG2_38 PG2_39 PG2_40 PG2_41
+  PG2_42 PG2_43 PG2_44 PG2_45 PG2_46 PG2_47 PG2_48 PG2_49 PG2_50 PG2_51
+  PG2_52 PG2_53 PG2_54 PG2_55 PG2_56 PG2_57 PG2_58 PG2_59 PG2_60 PG2_61
+  PG2_62 PG2_63 PG2_64 PG2_65 PG2_66 PG2_67 PG2_68 PG2_69 PG2_70 PG2_71
+  PG2_72 PG2_73 PG2_74 PG2_75 PG2_76 PG2_77 PG2_78 PG2_79 PG2_80 PG2_81
+  PG2_82 PG2_83 PG2_84 PG2_85 PG2_86 PG2_87 PG2_88 PG2_89 PG2_90 PG2_91
+  PG2_92 PG2_93 PG2_94 PG2_95 PG2_96 PG2_97 PG2_98 PG2_99 PG2_100 PG2_101
+  PG2_102 PG2_103 PG2_104 PG2_105 PG2_106 PG2_107 PG2_108 PG2_109 PG2_110
+  PG2_111 PG2_112 PG2_113 PG2_114 PG2_115 PG2_116 PG2_117 PG2_118 PG2_119
+  PG2_120 PG2_121 PG2_122 PG2_123 PG2_124 PG2_125 PG2_126 PG2_127 PG2_128
+  PG2_129 PG2_130 PG2_131 PG2_132 PG2_133 PG2_134 PG2_135 PG2_136 PG2_137
+  PG2_138 PG2_139 PG2_140 PG2_141 PG2_142 PG2_143 PG2_144 PG2_145 PG2_146
+  PG2_147 PG2_148 PG2_149 PG2_150 PG2_151 PG2_152 PG2_153 PG2_154 PG2_155
+  PG2_156 PG2_157 PG2_158 PG2_159 PG2_160 PG2_161 PG2_162 PG2_163 PG2_164
+  PG2_165 PG2_166 PG2_167 PG2_168 PG2_169 PG2_170 PG2_171 PG2_172 PG2_173
+  PG2_174 PG2_175 PG2_176 PG2_177 PG2_178 PG2_179 PG2_180 PG2_181 PG2_182
+  PG2_183 PG2_184 PG2_185 PG2_186 PG2_187 PG2_188 PG2_189 PG2_190 PG2_191
+  PG2_192 PG2_193 PG2_194 PG2_195 PG2_196 PG2_197 PG2_198 PG2_199 PG2_200
+  PG2_201 PG2_202 PG2_203 PG2_204 PG2_205 PG2_206 PG2_207 PG2_208 PG2_209
+  PG2_210 PG2_211 PG2_212 PG2_213 PG2_214 PG2_215 PG2_216 PG2_217 PG2_218
+  PG2_219 PG2_220 PG2_221 PG2_222 PG2_223 PG2_224 PG2_225 PG2_226 PG2_227
+  PG2_228 PG2_229 PG2_230 PG2_231 PG2_232 PG2_233 PG2_234 PG2_235 PG2_236
+  PG2_237 PG2_238 PG2_239 PG2_240 PG2_241 PG2_242 PG2_243 PG2_244 PG2_245
+  PG2_246 PG2_247 PG2_248 PG2_249 PG2_250 PG2_251 PG2_252 PG2_253 PG2_254
+  PG2_255 PG2_256 PG2_257 RBTPTERM_0 RBTPTERM_1 RDTN_0 RDTN_1 RET_0 RET_1
+  RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0 RRA1_1 RRA1__0 RRA1__1 RREN_0 RREN_1
+  TIEHI TIELO WBT_0 WBT_1 XP0_0 XP0_1 XP1_0 XP1_1 XP2_0 XP2_1 XP3_0 XP3_1
+  XP4_0 XP4_1 XP5_0 XP5_1 XP6_0 XP6_1 XP7_0 XP7_1 XP8_0 XP8_1 XP9_0 XP9_1
+  XP10_0 XP10_1 XP11_0 XP11_1 XP12_0 XP12_1 XP13_0 XP13_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpMODEL_ROW: 4240 flat devices **
XI0_0 BLA_128 BLA_127 BLA_126 BLA_125 BLA_124 BLA_123 BLA_122 BLA_121 BLA_120
+  BLA_119 BLA_118 BLA_117 BLA_116 BLA_115 BLA_114 BLA_113 BLA_112 BLA_111
+  BLA_110 BLA_109 BLA_108 BLA_107 BLA_106 BLA_105 BLA_104 BLA_103 BLA_102
+  BLA_101 BLA_100 BLA_99 BLA_98 BLA_97 BLA_96 BLA_95 BLA_94 BLA_93 BLA_92
+  BLA_91 BLA_90 BLA_89 BLA_88 BLA_87 BLA_86 BLA_85 BLA_84 BLA_83 BLA_82
+  BLA_81 BLA_80 BLA_79 BLA_78 BLA_77 BLA_76 BLA_75 BLA_74 BLA_73 BLA_72
+  BLA_71 BLA_70 BLA_69 BLA_68 BLA_67 BLA_66 BLA_65 BLA_64 BLA_63 BLA_62
+  BLA_61 BLA_60 BLA_59 BLA_58 BLA_57 BLA_56 BLA_55 BLA_54 BLA_53 BLA_52
+  BLA_51 BLA_50 BLA_49 BLA_48 BLA_47 BLA_46 BLA_45 BLA_44 BLA_43 BLA_42
+  BLA_41 BLA_40 BLA_39 BLA_38 BLA_37 BLA_36 BLA_35 BLA_34 BLA_33 BLA_32
+  BLA_31 BLA_30 BLA_29 BLA_28 BLA_27 BLA_26 BLA_25 BLA_24 BLA_23 BLA_22
+  BLA_21 BLA_20 BLA_19 BLA_18 BLA_17 BLA_16 BLA_15 BLA_14 BLA_13 BLA_12
+  BLA_11 BLA_10 BLA_9 BLA_8 BLA_7 BLA_6 BLA_5 BLA_4 BLA_3 BLA_2 BLA_1 BLA_0
+  BLA__128 BLA__127 BLA__126 BLA__125 BLA__124 BLA__123 BLA__122 BLA__121
+  BLA__120 BLA__119 BLA__118 BLA__117 BLA__116 BLA__115 BLA__114 BLA__113
+  BLA__112 BLA__111 BLA__110 BLA__109 BLA__108 BLA__107 BLA__106 BLA__105
+  BLA__104 BLA__103 BLA__102 BLA__101 BLA__100 BLA__99 BLA__98 BLA__97
+  BLA__96 BLA__95 BLA__94 BLA__93 BLA__92 BLA__91 BLA__90 BLA__89 BLA__88
+  BLA__87 BLA__86 BLA__85 BLA__84 BLA__83 BLA__82 BLA__81 BLA__80 BLA__79
+  BLA__78 BLA__77 BLA__76 BLA__75 BLA__74 BLA__73 BLA__72 BLA__71 BLA__70
+  BLA__69 BLA__68 BLA__67 BLA__66 BLA__65 BLA__64 BLA__63 BLA__62 BLA__61
+  BLA__60 BLA__59 BLA__58 BLA__57 BLA__56 BLA__55 BLA__54 BLA__53 BLA__52
+  BLA__51 BLA__50 BLA__49 BLA__48 BLA__47 BLA__46 BLA__45 BLA__44 BLA__43
+  BLA__42 BLA__41 BLA__40 BLA__39 BLA__38 BLA__37 BLA__36 BLA__35 BLA__34
+  BLA__33 BLA__32 BLA__31 BLA__30 BLA__29 BLA__28 BLA__27 BLA__26 BLA__25
+  BLA__24 BLA__23 BLA__22 BLA__21 BLA__20 BLA__19 BLA__18 BLA__17 BLA__16
+  BLA__15 BLA__14 BLA__13 BLA__12 BLA__11 BLA__10 BLA__9 BLA__8 BLA__7 BLA__6
+  BLA__5 BLA__4 BLA__3 BLA__2 BLA__1 BLA__0 BLB_127 BLB_126 BLB_125 BLB_124
+  BLB_123 BLB_122 BLB_121 BLB_120 BLB_119 BLB_118 BLB_117 BLB_116 BLB_115
+  BLB_114 BLB_113 BLB_112 BLB_111 BLB_110 BLB_109 BLB_108 BLB_107 BLB_106
+  BLB_105 BLB_104 BLB_103 BLB_102 BLB_101 BLB_100 BLB_99 BLB_98 BLB_97 BLB_96
+  BLB_95 BLB_94 BLB_93 BLB_92 BLB_91 BLB_90 BLB_89 BLB_88 BLB_87 BLB_86
+  BLB_85 BLB_84 BLB_83 BLB_82 BLB_81 BLB_80 BLB_79 BLB_78 BLB_77 BLB_76
+  BLB_75 BLB_74 BLB_73 BLB_72 BLB_71 BLB_70 BLB_69 BLB_68 BLB_67 BLB_66
+  BLB_65 BLB_64 BLB_63 BLB_62 BLB_61 BLB_60 BLB_59 BLB_58 BLB_57 BLB_56
+  BLB_55 BLB_54 BLB_53 BLB_52 BLB_51 BLB_50 BLB_49 BLB_48 BLB_47 BLB_46
+  BLB_45 BLB_44 BLB_43 BLB_42 BLB_41 BLB_40 BLB_39 BLB_38 BLB_37 BLB_36
+  BLB_35 BLB_34 BLB_33 BLB_32 BLB_31 BLB_30 BLB_29 BLB_28 BLB_27 BLB_26
+  BLB_25 BLB_24 BLB_23 BLB_22 BLB_21 BLB_20 BLB_19 BLB_18 BLB_17 BLB_16
+  BLB_15 BLB_14 BLB_13 BLB_12 BLB_11 BLB_10 BLB_9 BLB_8 BLB_7 BLB_6 BLB_5
+  BLB_4 BLB_3 BLB_2 BLB_1 BLB_0 BLB__128 BLB__127 BLB__126 BLB__125 BLB__124
+  BLB__123 BLB__122 BLB__121 BLB__120 BLB__119 BLB__118 BLB__117 BLB__116
+  BLB__115 BLB__114 BLB__113 BLB__112 BLB__111 BLB__110 BLB__109 BLB__108
+  BLB__107 BLB__106 BLB__105 BLB__104 BLB__103 BLB__102 BLB__101 BLB__100
+  BLB__99 BLB__98 BLB__97 BLB__96 BLB__95 BLB__94 BLB__93 BLB__92 BLB__91
+  BLB__90 BLB__89 BLB__88 BLB__87 BLB__86 BLB__85 BLB__84 BLB__83 BLB__82
+  BLB__81 BLB__80 BLB__79 BLB__78 BLB__77 BLB__76 BLB__75 BLB__74 BLB__73
+  BLB__72 BLB__71 BLB__70 BLB__69 BLB__68 BLB__67 BLB__66 BLB__65 BLB__64
+  BLB__63 BLB__62 BLB__61 BLB__60 BLB__59 BLB__58 BLB__57 BLB__56 BLB__55
+  BLB__54 BLB__53 BLB__52 BLB__51 BLB__50 BLB__49 BLB__48 BLB__47 BLB__46
+  BLB__45 BLB__44 BLB__43 BLB__42 BLB__41 BLB__40 BLB__39 BLB__38 BLB__37
+  BLB__36 BLB__35 BLB__34 BLB__33 BLB__32 BLB__31 BLB__30 BLB__29 BLB__28
+  BLB__27 BLB__26 BLB__25 BLB__24 BLB__23 BLB__22 BLB__21 BLB__20 BLB__19
+  BLB__18 BLB__17 BLB__16 BLB__15 BLB__14 BLB__13 BLB__12 BLB__11 BLB__10
+  BLB__9 BLB__8 BLB__7 BLB__6 BLB__5 BLB__4 BLB__3 BLB__2 BLB__1 BLB__0
+  GDL_128 GDL_127 GDL_126 GDL_125 GDL_124 GDL_123 GDL_122 GDL_121 GDL_120
+  GDL_119 GDL_118 GDL_117 GDL_116 GDL_115 GDL_114 GDL_113 GDL_112 GDL_111
+  GDL_110 GDL_109 GDL_108 GDL_107 GDL_106 GDL_105 GDL_104 GDL_103 GDL_102
+  GDL_101 GDL_100 GDL_99 GDL_98 GDL_97 GDL_96 GDL_95 GDL_94 GDL_93 GDL_92
+  GDL_91 GDL_90 GDL_89 GDL_88 GDL_87 GDL_86 GDL_85 GDL_84 GDL_83 GDL_82
+  GDL_81 GDL_80 GDL_79 GDL_78 GDL_77 GDL_76 GDL_75 GDL_74 GDL_73 GDL_72
+  GDL_71 GDL_70 GDL_69 GDL_68 GDL_67 GDL_66 GDL_65 GDL_64 GDL_63 GDL_62
+  GDL_61 GDL_60 GDL_59 GDL_58 GDL_57 GDL_56 GDL_55 GDL_54 GDL_53 GDL_52
+  GDL_51 GDL_50 GDL_49 GDL_48 GDL_47 GDL_46 GDL_45 GDL_44 GDL_43 GDL_42
+  GDL_41 GDL_40 GDL_39 GDL_38 GDL_37 GDL_36 GDL_35 GDL_34 GDL_33 GDL_32
+  GDL_31 GDL_30 GDL_29 GDL_28 GDL_27 GDL_26 GDL_25 GDL_24 GDL_23 GDL_22
+  GDL_21 GDL_20 GDL_19 GDL_18 GDL_17 GDL_16 GDL_15 GDL_14 GDL_13 GDL_12
+  GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5 GDL_4 GDL_3 GDL_2 GDL_1 GDL_0
+  MBL_0 PG1_128 PG1_127 PG1_126 PG1_125 PG1_124 PG1_123 PG1_122 PG1_121
+  PG1_120 PG1_119 PG1_118 PG1_117 PG1_116 PG1_115 PG1_114 PG1_113 PG1_112
+  PG1_111 PG1_110 PG1_109 PG1_108 PG1_107 PG1_106 PG1_105 PG1_104 PG1_103
+  PG1_102 PG1_101 PG1_100 PG1_99 PG1_98 PG1_97 PG1_96 PG1_95 PG1_94 PG1_93
+  PG1_92 PG1_91 PG1_90 PG1_89 PG1_88 PG1_87 PG1_86 PG1_85 PG1_84 PG1_83
+  PG1_82 PG1_81 PG1_80 PG1_79 PG1_78 PG1_77 PG1_76 PG1_75 PG1_74 PG1_73
+  PG1_72 PG1_71 PG1_70 PG1_69 PG1_68 PG1_67 PG1_66 PG1_65 PG1_64 PG1_63
+  PG1_62 PG1_61 PG1_60 PG1_59 PG1_58 PG1_57 PG1_56 PG1_55 PG1_54 PG1_53
+  PG1_52 PG1_51 PG1_50 PG1_49 PG1_48 PG1_47 PG1_46 PG1_45 PG1_44 PG1_43
+  PG1_42 PG1_41 PG1_40 PG1_39 PG1_38 PG1_37 PG1_36 PG1_35 PG1_34 PG1_33
+  PG1_32 PG1_31 PG1_30 PG1_29 PG1_28 PG1_27 PG1_26 PG1_25 PG1_24 PG1_23
+  PG1_22 PG1_21 PG1_20 PG1_19 PG1_18 PG1_17 PG1_16 PG1_15 PG1_14 PG1_13
+  PG1_12 PG1_11 PG1_10 PG1_9 PG1_8 PG1_7 PG1_6 PG1_5 PG1_4 PG1_3 PG1_2 PG1_1
+  PG1_0 PG2_128 PG2_127 PG2_126 PG2_125 PG2_124 PG2_123 PG2_122 PG2_121
+  PG2_120 PG2_119 PG2_118 PG2_117 PG2_116 PG2_115 PG2_114 PG2_113 PG2_112
+  PG2_111 PG2_110 PG2_109 PG2_108 PG2_107 PG2_106 PG2_105 PG2_104 PG2_103
+  PG2_102 PG2_101 PG2_100 PG2_99 PG2_98 PG2_97 PG2_96 PG2_95 PG2_94 PG2_93
+  PG2_92 PG2_91 PG2_90 PG2_89 PG2_88 PG2_87 PG2_86 PG2_85 PG2_84 PG2_83
+  PG2_82 PG2_81 PG2_80 PG2_79 PG2_78 PG2_77 PG2_76 PG2_75 PG2_74 PG2_73
+  PG2_72 PG2_71 PG2_70 PG2_69 PG2_68 PG2_67 PG2_66 PG2_65 PG2_64 PG2_63
+  PG2_62 PG2_61 PG2_60 PG2_59 PG2_58 PG2_57 PG2_56 PG2_55 PG2_54 PG2_53
+  PG2_52 PG2_51 PG2_50 PG2_49 PG2_48 PG2_47 PG2_46 PG2_45 PG2_44 PG2_43
+  PG2_42 PG2_41 PG2_40 PG2_39 PG2_38 PG2_37 PG2_36 PG2_35 PG2_34 PG2_33
+  PG2_32 PG2_31 PG2_30 PG2_29 PG2_28 PG2_27 PG2_26 PG2_25 PG2_24 PG2_23
+  PG2_22 PG2_21 PG2_20 PG2_19 PG2_18 PG2_17 PG2_16 PG2_15 PG2_14 PG2_13
+  PG2_12 PG2_11 PG2_10 PG2_9 PG2_8 PG2_7 PG2_6 PG2_5 PG2_4 PG2_3 PG2_2 PG2_1
+  PG2_0 TIEHI TIEHI TIELO TIELO WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpMWL_ROW_L
XI1_0 AX0TRACK_0 AX1TRACK_0 AX2TRACK_0 AX3TRACK_0 AX4TRACK_0 AX5TRACK_0
+  AY0TRACK_0 AY1TRACK_0 BS0N_0 BS1N_0 BS2N_0 BTP_0 GTP_0 GTPD_0 GTPDE_0
+  GTPMW_0 LGWE_0 LGWET_0 MBL_0 MBL_ERR2_0 MGDLE_0 MGDLS_0 MGTPE_0 MGTPS_0 WLB
+  WLB RBTPTERM_0 RDTN_0 RET_0 RRA0_0 RRA0__0 RRA1_0 RRA1__0 RREN_0 TIEHI
+  TIELO WBT_0 XP0_0 XP1_0 XP2_0 XP3_0 XP4_0 XP5_0 XP6_0 XP7_0 XP8_0 XP9_0
+  XP10_0 XP11_0 XP12_0 XP13_0 VDDPE VDDCE VSSE pe_spad_1024x16_dpMWDX
XI2_0 AX0TRACK_1 AX1TRACK_1 AX2TRACK_1 AX3TRACK_1 AX4TRACK_1 AX5TRACK_1
+  AY0TRACK_1 AY1TRACK_1 BS0N_1 BS1N_1 BS2N_1 BTP_1 GTP_1 GTPD_1 GTPDE_1
+  GTPMW_1 LGWE_1 LGWET_1 MBL_1 MBL_ERR2_1 MGDLE_1 MGDLS_1 MGTPE_1 MGTPS_1 MWL
+  MWL RBTPTERM_1 RDTN_1 RET_1 RRA0_1 RRA0__1 RRA1_1 RRA1__1 RREN_1 TIEHI
+  TIELO WBT_1 XP0_1 XP1_1 XP2_1 XP3_1 XP4_1 XP5_1 XP6_1 XP7_1 XP8_1 XP9_1
+  XP10_1 XP11_1 XP12_1 XP13_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpMWDX
XI3_0 BLA_129 BLA_130 BLA_131 BLA_132 BLA_133 BLA_134 BLA_135 BLA_136 BLA_137
+  BLA_138 BLA_139 BLA_140 BLA_141 BLA_142 BLA_143 BLA_144 BLA_145 BLA_146
+  BLA_147 BLA_148 BLA_149 BLA_150 BLA_151 BLA_152 BLA_153 BLA_154 BLA_155
+  BLA_156 BLA_157 BLA_158 BLA_159 BLA_160 BLA_161 BLA_162 BLA_163 BLA_164
+  BLA_165 BLA_166 BLA_167 BLA_168 BLA_169 BLA_170 BLA_171 BLA_172 BLA_173
+  BLA_174 BLA_175 BLA_176 BLA_177 BLA_178 BLA_179 BLA_180 BLA_181 BLA_182
+  BLA_183 BLA_184 BLA_185 BLA_186 BLA_187 BLA_188 BLA_189 BLA_190 BLA_191
+  BLA_192 BLA_193 BLA_194 BLA_195 BLA_196 BLA_197 BLA_198 BLA_199 BLA_200
+  BLA_201 BLA_202 BLA_203 BLA_204 BLA_205 BLA_206 BLA_207 BLA_208 BLA_209
+  BLA_210 BLA_211 BLA_212 BLA_213 BLA_214 BLA_215 BLA_216 BLA_217 BLA_218
+  BLA_219 BLA_220 BLA_221 BLA_222 BLA_223 BLA_224 BLA_225 BLA_226 BLA_227
+  BLA_228 BLA_229 BLA_230 BLA_231 BLA_232 BLA_233 BLA_234 BLA_235 BLA_236
+  BLA_237 BLA_238 BLA_239 BLA_240 BLA_241 BLA_242 BLA_243 BLA_244 BLA_245
+  BLA_246 BLA_247 BLA_248 BLA_249 BLA_250 BLA_251 BLA_252 BLA_253 BLA_254
+  BLA_255 BLA_256 BLA_257 BLA__129 BLA__130 BLA__131 BLA__132 BLA__133
+  BLA__134 BLA__135 BLA__136 BLA__137 BLA__138 BLA__139 BLA__140 BLA__141
+  BLA__142 BLA__143 BLA__144 BLA__145 BLA__146 BLA__147 BLA__148 BLA__149
+  BLA__150 BLA__151 BLA__152 BLA__153 BLA__154 BLA__155 BLA__156 BLA__157
+  BLA__158 BLA__159 BLA__160 BLA__161 BLA__162 BLA__163 BLA__164 BLA__165
+  BLA__166 BLA__167 BLA__168 BLA__169 BLA__170 BLA__171 BLA__172 BLA__173
+  BLA__174 BLA__175 BLA__176 BLA__177 BLA__178 BLA__179 BLA__180 BLA__181
+  BLA__182 BLA__183 BLA__184 BLA__185 BLA__186 BLA__187 BLA__188 BLA__189
+  BLA__190 BLA__191 BLA__192 BLA__193 BLA__194 BLA__195 BLA__196 BLA__197
+  BLA__198 BLA__199 BLA__200 BLA__201 BLA__202 BLA__203 BLA__204 BLA__205
+  BLA__206 BLA__207 BLA__208 BLA__209 BLA__210 BLA__211 BLA__212 BLA__213
+  BLA__214 BLA__215 BLA__216 BLA__217 BLA__218 BLA__219 BLA__220 BLA__221
+  BLA__222 BLA__223 BLA__224 BLA__225 BLA__226 BLA__227 BLA__228 BLA__229
+  BLA__230 BLA__231 BLA__232 BLA__233 BLA__234 BLA__235 BLA__236 BLA__237
+  BLA__238 BLA__239 BLA__240 BLA__241 BLA__242 BLA__243 BLA__244 BLA__245
+  BLA__246 BLA__247 BLA__248 BLA__249 BLA__250 BLA__251 BLA__252 BLA__253
+  BLA__254 BLA__255 BLA__256 BLA__257 BLB_128 BLB_129 BLB_130 BLB_131 BLB_132
+  BLB_133 BLB_134 BLB_135 BLB_136 BLB_137 BLB_138 BLB_139 BLB_140 BLB_141
+  BLB_142 BLB_143 BLB_144 BLB_145 BLB_146 BLB_147 BLB_148 BLB_149 BLB_150
+  BLB_151 BLB_152 BLB_153 BLB_154 BLB_155 BLB_156 BLB_157 BLB_158 BLB_159
+  BLB_160 BLB_161 BLB_162 BLB_163 BLB_164 BLB_165 BLB_166 BLB_167 BLB_168
+  BLB_169 BLB_170 BLB_171 BLB_172 BLB_173 BLB_174 BLB_175 BLB_176 BLB_177
+  BLB_178 BLB_179 BLB_180 BLB_181 BLB_182 BLB_183 BLB_184 BLB_185 BLB_186
+  BLB_187 BLB_188 BLB_189 BLB_190 BLB_191 BLB_192 BLB_193 BLB_194 BLB_195
+  BLB_196 BLB_197 BLB_198 BLB_199 BLB_200 BLB_201 BLB_202 BLB_203 BLB_204
+  BLB_205 BLB_206 BLB_207 BLB_208 BLB_209 BLB_210 BLB_211 BLB_212 BLB_213
+  BLB_214 BLB_215 BLB_216 BLB_217 BLB_218 BLB_219 BLB_220 BLB_221 BLB_222
+  BLB_223 BLB_224 BLB_225 BLB_226 BLB_227 BLB_228 BLB_229 BLB_230 BLB_231
+  BLB_232 BLB_233 BLB_234 BLB_235 BLB_236 BLB_237 BLB_238 BLB_239 BLB_240
+  BLB_241 BLB_242 BLB_243 BLB_244 BLB_245 BLB_246 BLB_247 BLB_248 BLB_249
+  BLB_250 BLB_251 BLB_252 BLB_253 BLB_254 BLB_255 BLB__129 BLB__130 BLB__131
+  BLB__132 BLB__133 BLB__134 BLB__135 BLB__136 BLB__137 BLB__138 BLB__139
+  BLB__140 BLB__141 BLB__142 BLB__143 BLB__144 BLB__145 BLB__146 BLB__147
+  BLB__148 BLB__149 BLB__150 BLB__151 BLB__152 BLB__153 BLB__154 BLB__155
+  BLB__156 BLB__157 BLB__158 BLB__159 BLB__160 BLB__161 BLB__162 BLB__163
+  BLB__164 BLB__165 BLB__166 BLB__167 BLB__168 BLB__169 BLB__170 BLB__171
+  BLB__172 BLB__173 BLB__174 BLB__175 BLB__176 BLB__177 BLB__178 BLB__179
+  BLB__180 BLB__181 BLB__182 BLB__183 BLB__184 BLB__185 BLB__186 BLB__187
+  BLB__188 BLB__189 BLB__190 BLB__191 BLB__192 BLB__193 BLB__194 BLB__195
+  BLB__196 BLB__197 BLB__198 BLB__199 BLB__200 BLB__201 BLB__202 BLB__203
+  BLB__204 BLB__205 BLB__206 BLB__207 BLB__208 BLB__209 BLB__210 BLB__211
+  BLB__212 BLB__213 BLB__214 BLB__215 BLB__216 BLB__217 BLB__218 BLB__219
+  BLB__220 BLB__221 BLB__222 BLB__223 BLB__224 BLB__225 BLB__226 BLB__227
+  BLB__228 BLB__229 BLB__230 BLB__231 BLB__232 BLB__233 BLB__234 BLB__235
+  BLB__236 BLB__237 BLB__238 BLB__239 BLB__240 BLB__241 BLB__242 BLB__243
+  BLB__244 BLB__245 BLB__246 BLB__247 BLB__248 BLB__249 BLB__250 BLB__251
+  BLB__252 BLB__253 BLB__254 BLB__255 BLB__256 BLB__257 GDL_129 GDL_130
+  GDL_131 GDL_132 GDL_133 GDL_134 GDL_135 GDL_136 GDL_137 GDL_138 GDL_139
+  GDL_140 GDL_141 GDL_142 GDL_143 GDL_144 GDL_145 GDL_146 GDL_147 GDL_148
+  GDL_149 GDL_150 GDL_151 GDL_152 GDL_153 GDL_154 GDL_155 GDL_156 GDL_157
+  GDL_158 GDL_159 GDL_160 GDL_161 GDL_162 GDL_163 GDL_164 GDL_165 GDL_166
+  GDL_167 GDL_168 GDL_169 GDL_170 GDL_171 GDL_172 GDL_173 GDL_174 GDL_175
+  GDL_176 GDL_177 GDL_178 GDL_179 GDL_180 GDL_181 GDL_182 GDL_183 GDL_184
+  GDL_185 GDL_186 GDL_187 GDL_188 GDL_189 GDL_190 GDL_191 GDL_192 GDL_193
+  GDL_194 GDL_195 GDL_196 GDL_197 GDL_198 GDL_199 GDL_200 GDL_201 GDL_202
+  GDL_203 GDL_204 GDL_205 GDL_206 GDL_207 GDL_208 GDL_209 GDL_210 GDL_211
+  GDL_212 GDL_213 GDL_214 GDL_215 GDL_216 GDL_217 GDL_218 GDL_219 GDL_220
+  GDL_221 GDL_222 GDL_223 GDL_224 GDL_225 GDL_226 GDL_227 GDL_228 GDL_229
+  GDL_230 GDL_231 GDL_232 GDL_233 GDL_234 GDL_235 GDL_236 GDL_237 GDL_238
+  GDL_239 GDL_240 GDL_241 GDL_242 GDL_243 GDL_244 GDL_245 GDL_246 GDL_247
+  GDL_248 GDL_249 GDL_250 GDL_251 GDL_252 GDL_253 GDL_254 GDL_255 GDL_256
+  GDL_257 MBL_1 PG1_129 PG1_130 PG1_131 PG1_132 PG1_133 PG1_134 PG1_135
+  PG1_136 PG1_137 PG1_138 PG1_139 PG1_140 PG1_141 PG1_142 PG1_143 PG1_144
+  PG1_145 PG1_146 PG1_147 PG1_148 PG1_149 PG1_150 PG1_151 PG1_152 PG1_153
+  PG1_154 PG1_155 PG1_156 PG1_157 PG1_158 PG1_159 PG1_160 PG1_161 PG1_162
+  PG1_163 PG1_164 PG1_165 PG1_166 PG1_167 PG1_168 PG1_169 PG1_170 PG1_171
+  PG1_172 PG1_173 PG1_174 PG1_175 PG1_176 PG1_177 PG1_178 PG1_179 PG1_180
+  PG1_181 PG1_182 PG1_183 PG1_184 PG1_185 PG1_186 PG1_187 PG1_188 PG1_189
+  PG1_190 PG1_191 PG1_192 PG1_193 PG1_194 PG1_195 PG1_196 PG1_197 PG1_198
+  PG1_199 PG1_200 PG1_201 PG1_202 PG1_203 PG1_204 PG1_205 PG1_206 PG1_207
+  PG1_208 PG1_209 PG1_210 PG1_211 PG1_212 PG1_213 PG1_214 PG1_215 PG1_216
+  PG1_217 PG1_218 PG1_219 PG1_220 PG1_221 PG1_222 PG1_223 PG1_224 PG1_225
+  PG1_226 PG1_227 PG1_228 PG1_229 PG1_230 PG1_231 PG1_232 PG1_233 PG1_234
+  PG1_235 PG1_236 PG1_237 PG1_238 PG1_239 PG1_240 PG1_241 PG1_242 PG1_243
+  PG1_244 PG1_245 PG1_246 PG1_247 PG1_248 PG1_249 PG1_250 PG1_251 PG1_252
+  PG1_253 PG1_254 PG1_255 PG1_256 PG1_257 PG2_129 PG2_130 PG2_131 PG2_132
+  PG2_133 PG2_134 PG2_135 PG2_136 PG2_137 PG2_138 PG2_139 PG2_140 PG2_141
+  PG2_142 PG2_143 PG2_144 PG2_145 PG2_146 PG2_147 PG2_148 PG2_149 PG2_150
+  PG2_151 PG2_152 PG2_153 PG2_154 PG2_155 PG2_156 PG2_157 PG2_158 PG2_159
+  PG2_160 PG2_161 PG2_162 PG2_163 PG2_164 PG2_165 PG2_166 PG2_167 PG2_168
+  PG2_169 PG2_170 PG2_171 PG2_172 PG2_173 PG2_174 PG2_175 PG2_176 PG2_177
+  PG2_178 PG2_179 PG2_180 PG2_181 PG2_182 PG2_183 PG2_184 PG2_185 PG2_186
+  PG2_187 PG2_188 PG2_189 PG2_190 PG2_191 PG2_192 PG2_193 PG2_194 PG2_195
+  PG2_196 PG2_197 PG2_198 PG2_199 PG2_200 PG2_201 PG2_202 PG2_203 PG2_204
+  PG2_205 PG2_206 PG2_207 PG2_208 PG2_209 PG2_210 PG2_211 PG2_212 PG2_213
+  PG2_214 PG2_215 PG2_216 PG2_217 PG2_218 PG2_219 PG2_220 PG2_221 PG2_222
+  PG2_223 PG2_224 PG2_225 PG2_226 PG2_227 PG2_228 PG2_229 PG2_230 PG2_231
+  PG2_232 PG2_233 PG2_234 PG2_235 PG2_236 PG2_237 PG2_238 PG2_239 PG2_240
+  PG2_241 PG2_242 PG2_243 PG2_244 PG2_245 PG2_246 PG2_247 PG2_248 PG2_249
+  PG2_250 PG2_251 PG2_252 PG2_253 PG2_254 PG2_255 PG2_256 PG2_257 TIEHI TIEHI
+  TIELO TIELO MWL VDDPE VDDCE VSSE pe_spad_1024x16_dpMWL_ROW_R
.ENDS pe_spad_1024x16_dpMODEL_ROW
****
.SUBCKT pe_spad_1024x16_dpCCMBL_COL_0 MBL TIEHI_0 TIEHI_1 TIELO WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCCMBL_COL_0: 512 flat devices **
XI0_1 VDDCE VSSE VSSE CORED_248 CORED__246 VSSE MBL NDIFF_244 PDIFF_242 VSSE
+  VSSE TIELO WLA_0 WLB_0 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_10 VDDCE VSSE VSSE CORED_302 CORED__300 VSSE MBL NDIFF_292 PDIFF_298 VSSE
+  VSSE TIELO WLA_9 WLB_9 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_11 VDDCE VSSE VSSE CORED_308 CORED__306 VSSE MBL NDIFF_304 PDIFF_298 VSSE
+  VSSE TIELO WLA_10 WLB_10 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_12 VDDCE VSSE VSSE CORED_314 CORED__312 VSSE MBL NDIFF_304 PDIFF_310 VSSE
+  VSSE TIELO WLA_11 WLB_11 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_13 VDDCE VSSE VSSE CORED_326 CORED__324 VSSE MBL NDIFF_322 PDIFF_310 VSSE
+  VSSE TIELO WLA_12 WLB_12 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_14 VDDCE VSSE VSSE CORED_338 CORED__336 VSSE MBL NDIFF_322 PDIFF_334 VSSE
+  VSSE TIELO WLA_13 WLB_13 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_15 VDDCE VSSE VSSE CORED_356 CORED__354 VSSE MBL NDIFF_352 PDIFF_334 VSSE
+  VSSE TIELO WLA_14 WLB_14 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_16 VDDCE VSSE VSSE CORED_372 CORED__370 VSSE MBL NDIFF_352 PDIFF VSSE VSSE
+  TIELO WLA_15 WLB_15 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_17 VDDCE VSSE VSSE CORED CORED_ VSSE MBL NDIFF PDIFF VSSE VSSE TIELO
+  WLA_16 WLB_16 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_18 VDDCE VSSE VSSE CORED_24 CORED__22 VSSE MBL NDIFF PDIFF_20 VSSE VSSE
+  TIELO WLA_17 WLB_17 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_19 VDDCE VSSE VSSE CORED_42 CORED__40 VSSE MBL NDIFF_38 PDIFF_20 VSSE VSSE
+  TIELO WLA_18 WLB_18 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_2 VDDCE VSSE VSSE CORED_254 CORED__252 VSSE MBL NDIFF_244 PDIFF_250 VSSE
+  VSSE TIELO WLA_1 WLB_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_20 VDDCE VSSE VSSE CORED_96 CORED__94 VSSE MBL NDIFF_38 PDIFF_92 VSSE VSSE
+  TIELO WLA_19 WLB_19 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_21 VDDCE VSSE VSSE CORED_102 CORED__100 VSSE MBL NDIFF_98 PDIFF_92 VSSE
+  VSSE TIELO WLA_20 WLB_20 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_22 VDDCE VSSE VSSE CORED_108 CORED__106 VSSE MBL NDIFF_98 PDIFF_104 VSSE
+  VSSE TIELO WLA_21 WLB_21 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_23 VDDCE VSSE VSSE CORED_120 CORED__118 VSSE MBL NDIFF_116 PDIFF_104 VSSE
+  VSSE TIELO WLA_22 WLB_22 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_24 VDDCE VSSE VSSE CORED_138 CORED__136 VSSE MBL NDIFF_116 PDIFF_134 VSSE
+  VSSE TIELO WLA_23 WLB_23 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_25 VDDCE VSSE VSSE CORED_156 CORED__154 VSSE MBL NDIFF_152 PDIFF_134 VSSE
+  VSSE TIELO WLA_24 WLB_24 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_26 VDDCE VSSE VSSE CORED_174 CORED__172 VSSE MBL NDIFF_152 PDIFF_170 VSSE
+  VSSE TIELO WLA_25 WLB_25 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_27 VDDCE VSSE VSSE CORED_192 CORED__190 VSSE MBL NDIFF_188 PDIFF_170 VSSE
+  VSSE TIELO WLA_26 WLB_26 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_28 VDDCE VSSE VSSE CORED_210 CORED__208 VSSE MBL NDIFF_188 PDIFF_206 VSSE
+  VSSE TIELO WLA_27 WLB_27 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_29 VDDCE VSSE VSSE CORED_222 CORED__220 VSSE MBL NDIFF_218 PDIFF_206 VSSE
+  VSSE TIELO WLA_28 WLB_28 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_3 VDDCE VSSE VSSE CORED_260 CORED__258 VSSE MBL NDIFF_256 PDIFF_250 VSSE
+  VSSE TIELO WLA_2 WLB_2 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_30 VDDCE VSSE VSSE CORED_320 CORED__318 VSSE MBL NDIFF_218 PDIFF_316 VSSE
+  VSSE TIELO WLA_29 WLB_29 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_31 VDDCE VSSE VSSE CORED_332 CORED__330 VSSE MBL NDIFF_328 PDIFF_316 VSSE
+  VSSE TIELO WLA_30 WLB_30 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_32 VDDCE VSSE VSSE CORED_344 CORED__342 VSSE MBL NDIFF_328 PDIFF_340 VSSE
+  VSSE TIELO WLA_31 WLB_31 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_33 VDDCE VSSE VSSE CORED_362 CORED__360 VSSE MBL NDIFF_358 PDIFF_340 VSSE
+  VSSE TIELO WLA_32 WLB_32 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_34 VDDCE VSSE VSSE CORED_376 CORED__374 VSSE MBL NDIFF_358 PDIFF_6 VSSE
+  VSSE TIELO WLA_33 WLB_33 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_35 VDDCE VSSE VSSE CORED_10 CORED__8 VSSE MBL NDIFF_4 PDIFF_6 VSSE VSSE
+  TIELO WLA_34 WLB_34 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_36 VDDCE VSSE VSSE CORED_30 CORED__28 VSSE MBL NDIFF_4 PDIFF_26 VSSE VSSE
+  TIELO WLA_35 WLB_35 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_37 VDDCE VSSE VSSE CORED_48 CORED__46 VSSE MBL NDIFF_44 PDIFF_26 VSSE VSSE
+  TIELO WLA_36 WLB_36 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_38 VDDCE VSSE VSSE CORED_60 CORED__58 VSSE MBL NDIFF_44 PDIFF_56 VSSE VSSE
+  TIELO WLA_37 WLB_37 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_39 VDDCE VSSE VSSE CORED_72 CORED__70 VSSE MBL NDIFF_68 PDIFF_56 VSSE VSSE
+  TIELO WLA_38 WLB_38 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_4 VDDCE VSSE VSSE CORED_266 CORED__264 VSSE MBL NDIFF_256 PDIFF_262 VSSE
+  VSSE TIELO WLA_3 WLB_3 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_40 VDDCE VSSE VSSE CORED_114 CORED__112 VSSE MBL NDIFF_68 PDIFF_110 VSSE
+  VSSE TIELO WLA_39 WLB_39 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_41 VDDCE VSSE VSSE CORED_126 CORED__124 VSSE MBL NDIFF_122 PDIFF_110 VSSE
+  VSSE TIELO WLA_40 WLB_40 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_42 VDDCE VSSE VSSE CORED_144 CORED__142 VSSE MBL NDIFF_122 PDIFF_140 VSSE
+  VSSE TIELO WLA_41 WLB_41 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_43 VDDCE VSSE VSSE CORED_162 CORED__160 VSSE MBL NDIFF_158 PDIFF_140 VSSE
+  VSSE TIELO WLA_42 WLB_42 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_44 VDDCE VSSE VSSE CORED_180 CORED__178 VSSE MBL NDIFF_158 PDIFF_176 VSSE
+  VSSE TIELO WLA_43 WLB_43 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_45 VDDCE VSSE VSSE CORED_198 CORED__196 VSSE MBL NDIFF_194 PDIFF_176 VSSE
+  VSSE TIELO WLA_44 WLB_44 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_46 VDDCE VSSE VSSE CORED_216 CORED__214 VSSE MBL NDIFF_194 PDIFF_212 VSSE
+  VSSE TIELO WLA_45 WLB_45 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_47 VDDCE VSSE VSSE CORED_228 CORED__226 VSSE MBL NDIFF_224 PDIFF_212 VSSE
+  VSSE TIELO WLA_46 WLB_46 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_48 VDDCE VSSE VSSE CORED_234 CORED__232 VSSE MBL NDIFF_224 PDIFF_230 VSSE
+  VSSE TIELO WLA_47 WLB_47 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_49 VDDCE VSSE VSSE CORED_240 CORED__238 VSSE MBL NDIFF_236 PDIFF_230 VSSE
+  VSSE TIELO WLA_48 WLB_48 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_5 VDDCE VSSE VSSE CORED_272 CORED__270 VSSE MBL NDIFF_268 PDIFF_262 VSSE
+  VSSE TIELO WLA_4 WLB_4 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_50 VDDCE VSSE VSSE CORED_350 CORED__348 VSSE MBL NDIFF_236 PDIFF_346 VSSE
+  VSSE TIELO WLA_49 WLB_49 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_51 VDDCE VSSE VSSE CORED_368 CORED__366 VSSE MBL NDIFF_364 PDIFF_346 VSSE
+  VSSE TIELO WLA_50 WLB_50 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_52 VDDCE VSSE VSSE CORED_380 CORED__378 VSSE MBL NDIFF_364 PDIFF_14 VSSE
+  VSSE TIELO WLA_51 WLB_51 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_53 VDDCE VSSE VSSE CORED_18 CORED__16 VSSE MBL NDIFF_12 PDIFF_14 VSSE VSSE
+  TIELO WLA_52 WLB_52 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_54 VDDCE VSSE VSSE CORED_36 CORED__34 VSSE MBL NDIFF_12 PDIFF_32 VSSE VSSE
+  TIELO WLA_53 WLB_53 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_55 VDDCE VSSE VSSE CORED_54 CORED__52 VSSE MBL NDIFF_50 PDIFF_32 VSSE VSSE
+  TIELO WLA_54 WLB_54 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_56 VDDCE VSSE VSSE CORED_66 CORED__64 VSSE MBL NDIFF_50 PDIFF_62 VSSE VSSE
+  TIELO WLA_55 WLB_55 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_57 VDDCE VSSE VSSE CORED_78 CORED__76 VSSE MBL NDIFF_74 PDIFF_62 VSSE VSSE
+  TIELO WLA_56 WLB_56 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_58 VDDCE VSSE VSSE CORED_84 CORED__82 VSSE MBL NDIFF_74 PDIFF_80 VSSE VSSE
+  TIELO WLA_57 WLB_57 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_59 VDDCE VSSE VSSE CORED_90 CORED__88 VSSE MBL NDIFF_86 PDIFF_80 VSSE VSSE
+  TIELO WLA_58 WLB_58 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_6 VDDCE VSSE VSSE CORED_278 CORED__276 VSSE MBL NDIFF_268 PDIFF_274 VSSE
+  VSSE TIELO WLA_5 WLB_5 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_60 VDDCE VSSE VSSE CORED_132 CORED__130 VSSE MBL NDIFF_86 PDIFF_128 VSSE
+  VSSE TIELO WLA_59 WLB_59 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_61 VDDCE VSSE VSSE CORED_150 CORED__148 VSSE MBL NDIFF_146 PDIFF_128 VSSE
+  VSSE TIELO WLA_60 WLB_60 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_62 VDDCE VSSE VSSE CORED_168 CORED__166 VSSE MBL NDIFF_146 PDIFF_164 VSSE
+  VSSE TIELO WLA_61 WLB_61 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_63 VDDCE VSSE VSSE CORED_186 CORED__184 VSSE MBL NDIFF_182 PDIFF_164 VSSE
+  VSSE TIELO WLA_62 WLB_62 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_64 VDDCE VSSE VSSE CORED_204 CORED__202 VSSE MBL NDIFF_182 PDIFF_200 VSSE
+  VSSE TIELO WLA_63 WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_7 VDDCE VSSE VSSE CORED_284 CORED__282 VSSE MBL NDIFF_280 PDIFF_274 VSSE
+  VSSE TIELO WLA_6 WLB_6 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_8 VDDCE VSSE VSSE CORED_290 CORED__288 VSSE MBL NDIFF_280 PDIFF_286 VSSE
+  VSSE TIELO WLA_7 WLB_7 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
XI0_9 VDDCE VSSE VSSE CORED_296 CORED__294 VSSE MBL NDIFF_292 PDIFF_286 VSSE
+  VSSE TIELO WLA_8 WLB_8 VDDPE VDDCE VSSE pe_spad_1024x16_dpCCEDGE_CCMBL
.ENDS pe_spad_1024x16_dpCCMBL_COL_0
****
.SUBCKT pe_spad_1024x16_dpCC BLA BLA_ BLB BLB_ CORED CORED_ GDL PG1 PG2 WLA
+  WLB VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCC: 8 flat devices **
M0 CORED_ WLB BLB_ VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N0/N00
M1 BLB WLB CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N2/N00
M2 BLA WLA CORED VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N3/N00
M3 CORED_ WLA BLA_ VSSE NCHPG_DPSR W=0.105U L=0.08U M=1 $name=/N4/N00
M4 VDDCE CORED CORED_ VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P1/P00
M5 CORED CORED_ VDDCE VDDCE PCHPU_DPSR W=0.09U L=0.07U M=1 $name=/P0/P00
M6 VSSE CORED_ CORED VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N5/N00
M7 CORED_ CORED VSSE VSSE NCHPD_DPSR W=0.315U L=0.065U M=1 $name=/N1/N00
.ENDS pe_spad_1024x16_dpCC
****
.SUBCKT pe_spad_1024x16_dpCCX BLA BLA_ BLB BLB_ GDL PG1 PG2 WLA WLB VDDPE
+  VDDCE VSSE
** pe_spad_1024x16_dpCCX: 8 flat devices **
XI0_0 BLA BLA_ BLB BLB_ CORED CORED_ GDL PG1 PG2 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCC
.ENDS pe_spad_1024x16_dpCCX
****
.SUBCKT pe_spad_1024x16_dpBIT_MUX BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6
+  BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1
+  BLA__2 BLA__3 BLA__4 BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11
+  BLA__12 BLA__13 BLA__14 BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6
+  BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11
+  BLB__12 BLB__13 BLB__14 BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6
+  GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1
+  PG1_2 PG1_3 PG1_4 PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13
+  PG1_14 PG1_15 PG2_0 PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9
+  PG2_10 PG2_11 PG2_12 PG2_13 PG2_14 PG2_15 WLA WLB VDDPE VDDCE VSSE
** pe_spad_1024x16_dpBIT_MUX: 128 flat devices **
XI0_0 BLA_0 BLA__0 BLB_0 BLB__0 GDL_0 PG1_0 PG2_0 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI10_0 BLA_10 BLA__10 BLB_10 BLB__10 GDL_10 PG1_10 PG2_10 WLA WLB VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpCCX
XI11_0 BLA_11 BLA__11 BLB_11 BLB__11 GDL_11 PG1_11 PG2_11 WLA WLB VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpCCX
XI12_0 BLA_12 BLA__12 BLB_12 BLB__12 GDL_12 PG1_12 PG2_12 WLA WLB VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpCCX
XI13_0 BLA_13 BLA__13 BLB_13 BLB__13 GDL_13 PG1_13 PG2_13 WLA WLB VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpCCX
XI14_0 BLA_14 BLA__14 BLB_14 BLB__14 GDL_14 PG1_14 PG2_14 WLA WLB VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpCCX
XI15_0 BLA_15 BLA__15 BLB_15 BLB__15 GDL_15 PG1_15 PG2_15 WLA WLB VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpCCX
XI1_0 BLA_1 BLA__1 BLB_1 BLB__1 GDL_1 PG1_1 PG2_1 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI2_0 BLA_2 BLA__2 BLB_2 BLB__2 GDL_2 PG1_2 PG2_2 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI3_0 BLA_3 BLA__3 BLB_3 BLB__3 GDL_3 PG1_3 PG2_3 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI4_0 BLA_4 BLA__4 BLB_4 BLB__4 GDL_4 PG1_4 PG2_4 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI5_0 BLA_5 BLA__5 BLB_5 BLB__5 GDL_5 PG1_5 PG2_5 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI6_0 BLA_6 BLA__6 BLB_6 BLB__6 GDL_6 PG1_6 PG2_6 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI7_0 BLA_7 BLA__7 BLB_7 BLB__7 GDL_7 PG1_7 PG2_7 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI8_0 BLA_8 BLA__8 BLB_8 BLB__8 GDL_8 PG1_8 PG2_8 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
XI9_0 BLA_9 BLA__9 BLB_9 BLB__9 GDL_9 PG1_9 PG2_9 WLA WLB VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCX
.ENDS pe_spad_1024x16_dpBIT_MUX
****
.SUBCKT pe_spad_1024x16_dpBIT_COL_B BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6
+  BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1
+  BLA__2 BLA__3 BLA__4 BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11
+  BLA__12 BLA__13 BLA__14 BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6
+  BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1
+  BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11
+  BLB__12 BLB__13 BLB__14 BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6
+  GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1
+  PG1_2 PG1_3 PG1_4 PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13
+  PG1_14 PG1_15 PG2_0 PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9
+  PG2_10 PG2_11 PG2_12 PG2_13 PG2_14 PG2_15 TIEHI_0 TIEHI_1 TIELO_0 TIELO_1
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31
+  WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41
+  WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51
+  WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61
+  WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39
+  WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49
+  WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59
+  WLB_60 WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpBIT_COL_B: 8192 flat devices **
XI0_1 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_0 WLB_0 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_10 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_9 WLB_9 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_11 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_10 WLB_10 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_12 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_11 WLB_11 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_13 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_12 WLB_12 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_14 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_13 WLB_13 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_15 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_14 WLB_14 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_16 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_15 WLB_15 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_17 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_16 WLB_16 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_18 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_17 WLB_17 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_19 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_18 WLB_18 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_2 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_1 WLB_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_20 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_19 WLB_19 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_21 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_20 WLB_20 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_22 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_21 WLB_21 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_23 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_22 WLB_22 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_24 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_23 WLB_23 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_25 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_24 WLB_24 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_26 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_25 WLB_25 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_27 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_26 WLB_26 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_28 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_27 WLB_27 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_29 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_28 WLB_28 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_3 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_2 WLB_2 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_30 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_29 WLB_29 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_31 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_30 WLB_30 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_32 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_31 WLB_31 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_33 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_32 WLB_32 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_34 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_33 WLB_33 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_35 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_34 WLB_34 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_36 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_35 WLB_35 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_37 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_36 WLB_36 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_38 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_37 WLB_37 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_39 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_38 WLB_38 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_4 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_3 WLB_3 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_40 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_39 WLB_39 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_41 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_40 WLB_40 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_42 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_41 WLB_41 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_43 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_42 WLB_42 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_44 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_43 WLB_43 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_45 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_44 WLB_44 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_46 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_45 WLB_45 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_47 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_46 WLB_46 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_48 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_47 WLB_47 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_49 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_48 WLB_48 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_5 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_4 WLB_4 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_50 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_49 WLB_49 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_51 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_50 WLB_50 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_52 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_51 WLB_51 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_53 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_52 WLB_52 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_54 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_53 WLB_53 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_55 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_54 WLB_54 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_56 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_55 WLB_55 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_57 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_56 WLB_56 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_58 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_57 WLB_57 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_59 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_58 WLB_58 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_6 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_5 WLB_5 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_60 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_59 WLB_59 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_61 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_60 WLB_60 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_62 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_61 WLB_61 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_63 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_62 WLB_62 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_64 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_63 WLB_63 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_MUX
XI0_7 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_6 WLB_6 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_8 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_7 WLB_7 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
XI0_9 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 WLA_8 WLB_8 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_MUX
.ENDS pe_spad_1024x16_dpBIT_COL_B
****
.SUBCKT pe_spad_1024x16_dpCORE_ARRAY_L_B BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5
+  BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16
+  BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26
+  BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36
+  BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46
+  BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56
+  BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66
+  BLA_67 BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76
+  BLA_77 BLA_78 BLA_79 BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86
+  BLA_87 BLA_88 BLA_89 BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96
+  BLA_97 BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105
+  BLA_106 BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114
+  BLA_115 BLA_116 BLA_117 BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123
+  BLA_124 BLA_125 BLA_126 BLA_127 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5
+  BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78
+  BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87
+  BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96
+  BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104
+  BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112
+  BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120
+  BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLB_0 BLB_1
+  BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13
+  BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23
+  BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33
+  BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43
+  BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53
+  BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63
+  BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71 BLB_72 BLB_73
+  BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81 BLB_82 BLB_83
+  BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91 BLB_92 BLB_93
+  BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101 BLB_102 BLB_103
+  BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110 BLB_111 BLB_112
+  BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119 BLB_120 BLB_121
+  BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB__0 BLB__1 BLB__2 BLB__3
+  BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13
+  BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22
+  BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31
+  BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40
+  BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49
+  BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58
+  BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67
+  BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73 BLB__74 BLB__75 BLB__76
+  BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82 BLB__83 BLB__84 BLB__85
+  BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91 BLB__92 BLB__93 BLB__94
+  BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100 BLB__101 BLB__102 BLB__103
+  BLB__104 BLB__105 BLB__106 BLB__107 BLB__108 BLB__109 BLB__110 BLB__111
+  BLB__112 BLB__113 BLB__114 BLB__115 BLB__116 BLB__117 BLB__118 BLB__119
+  BLB__120 BLB__121 BLB__122 BLB__123 BLB__124 BLB__125 BLB__126 BLB__127
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51
+  GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61
+  GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71
+  GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81
+  GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91
+  GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101
+  GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110
+  GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119
+  GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 MBL PG1_0
+  PG1_1 PG1_2 PG1_3 PG1_4 PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12
+  PG1_13 PG1_14 PG1_15 PG1_16 PG1_17 PG1_18 PG1_19 PG1_20 PG1_21 PG1_22
+  PG1_23 PG1_24 PG1_25 PG1_26 PG1_27 PG1_28 PG1_29 PG1_30 PG1_31 PG1_32
+  PG1_33 PG1_34 PG1_35 PG1_36 PG1_37 PG1_38 PG1_39 PG1_40 PG1_41 PG1_42
+  PG1_43 PG1_44 PG1_45 PG1_46 PG1_47 PG1_48 PG1_49 PG1_50 PG1_51 PG1_52
+  PG1_53 PG1_54 PG1_55 PG1_56 PG1_57 PG1_58 PG1_59 PG1_60 PG1_61 PG1_62
+  PG1_63 PG1_64 PG1_65 PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71 PG1_72
+  PG1_73 PG1_74 PG1_75 PG1_76 PG1_77 PG1_78 PG1_79 PG1_80 PG1_81 PG1_82
+  PG1_83 PG1_84 PG1_85 PG1_86 PG1_87 PG1_88 PG1_89 PG1_90 PG1_91 PG1_92
+  PG1_93 PG1_94 PG1_95 PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101 PG1_102
+  PG1_103 PG1_104 PG1_105 PG1_106 PG1_107 PG1_108 PG1_109 PG1_110 PG1_111
+  PG1_112 PG1_113 PG1_114 PG1_115 PG1_116 PG1_117 PG1_118 PG1_119 PG1_120
+  PG1_121 PG1_122 PG1_123 PG1_124 PG1_125 PG1_126 PG1_127 PG2_0 PG2_1 PG2_2
+  PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12 PG2_13
+  PG2_14 PG2_15 PG2_16 PG2_17 PG2_18 PG2_19 PG2_20 PG2_21 PG2_22 PG2_23
+  PG2_24 PG2_25 PG2_26 PG2_27 PG2_28 PG2_29 PG2_30 PG2_31 PG2_32 PG2_33
+  PG2_34 PG2_35 PG2_36 PG2_37 PG2_38 PG2_39 PG2_40 PG2_41 PG2_42 PG2_43
+  PG2_44 PG2_45 PG2_46 PG2_47 PG2_48 PG2_49 PG2_50 PG2_51 PG2_52 PG2_53
+  PG2_54 PG2_55 PG2_56 PG2_57 PG2_58 PG2_59 PG2_60 PG2_61 PG2_62 PG2_63
+  PG2_64 PG2_65 PG2_66 PG2_67 PG2_68 PG2_69 PG2_70 PG2_71 PG2_72 PG2_73
+  PG2_74 PG2_75 PG2_76 PG2_77 PG2_78 PG2_79 PG2_80 PG2_81 PG2_82 PG2_83
+  PG2_84 PG2_85 PG2_86 PG2_87 PG2_88 PG2_89 PG2_90 PG2_91 PG2_92 PG2_93
+  PG2_94 PG2_95 PG2_96 PG2_97 PG2_98 PG2_99 PG2_100 PG2_101 PG2_102 PG2_103
+  PG2_104 PG2_105 PG2_106 PG2_107 PG2_108 PG2_109 PG2_110 PG2_111 PG2_112
+  PG2_113 PG2_114 PG2_115 PG2_116 PG2_117 PG2_118 PG2_119 PG2_120 PG2_121
+  PG2_122 PG2_123 PG2_124 PG2_125 PG2_126 PG2_127 TIEHI_0 TIEHI_1 TIELO WLA_0
+  WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12
+  WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22
+  WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32
+  WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42
+  WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52
+  WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62
+  WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10
+  WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20
+  WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30
+  WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40
+  WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50
+  WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60
+  WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCORE_ARRAY_L_B: 66048 flat devices **
XI0_0 MBL TIEHI_0 TIEHI_1 TIELO WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCMBL_COL_0
XI1_0 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1
+  WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE
+  VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI2_0 BLA_31 BLA_30 BLA_29 BLA_28 BLA_27 BLA_26 BLA_25 BLA_24 BLA_23 BLA_22
+  BLA_21 BLA_20 BLA_19 BLA_18 BLA_17 BLA_16 BLA__31 BLA__30 BLA__29 BLA__28
+  BLA__27 BLA__26 BLA__25 BLA__24 BLA__23 BLA__22 BLA__21 BLA__20 BLA__19
+  BLA__18 BLA__17 BLA__16 BLB_31 BLB_30 BLB_29 BLB_28 BLB_27 BLB_26 BLB_25
+  BLB_24 BLB_23 BLB_22 BLB_21 BLB_20 BLB_19 BLB_18 BLB_17 BLB_16 BLB__31
+  BLB__30 BLB__29 BLB__28 BLB__27 BLB__26 BLB__25 BLB__24 BLB__23 BLB__22
+  BLB__21 BLB__20 BLB__19 BLB__18 BLB__17 BLB__16 GDL_31 GDL_30 GDL_29 GDL_28
+  GDL_27 GDL_26 GDL_25 GDL_24 GDL_23 GDL_22 GDL_21 GDL_20 GDL_19 GDL_18
+  GDL_17 GDL_16 PG1_31 PG1_30 PG1_29 PG1_28 PG1_27 PG1_26 PG1_25 PG1_24
+  PG1_23 PG1_22 PG1_21 PG1_20 PG1_19 PG1_18 PG1_17 PG1_16 PG2_31 PG2_30
+  PG2_29 PG2_28 PG2_27 PG2_26 PG2_25 PG2_24 PG2_23 PG2_22 PG2_21 PG2_20
+  PG2_19 PG2_18 PG2_17 PG2_16 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI3_0 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39 BLA_40 BLA_41
+  BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA__32 BLA__33 BLA__34 BLA__35
+  BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42 BLA__43 BLA__44
+  BLA__45 BLA__46 BLA__47 BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38
+  BLB_39 BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB__32
+  BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41
+  BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 PG1_32 PG1_33 PG1_34 PG1_35 PG1_36 PG1_37 PG1_38 PG1_39
+  PG1_40 PG1_41 PG1_42 PG1_43 PG1_44 PG1_45 PG1_46 PG1_47 PG2_32 PG2_33
+  PG2_34 PG2_35 PG2_36 PG2_37 PG2_38 PG2_39 PG2_40 PG2_41 PG2_42 PG2_43
+  PG2_44 PG2_45 PG2_46 PG2_47 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI4_0 BLA_63 BLA_62 BLA_61 BLA_60 BLA_59 BLA_58 BLA_57 BLA_56 BLA_55 BLA_54
+  BLA_53 BLA_52 BLA_51 BLA_50 BLA_49 BLA_48 BLA__63 BLA__62 BLA__61 BLA__60
+  BLA__59 BLA__58 BLA__57 BLA__56 BLA__55 BLA__54 BLA__53 BLA__52 BLA__51
+  BLA__50 BLA__49 BLA__48 BLB_63 BLB_62 BLB_61 BLB_60 BLB_59 BLB_58 BLB_57
+  BLB_56 BLB_55 BLB_54 BLB_53 BLB_52 BLB_51 BLB_50 BLB_49 BLB_48 BLB__63
+  BLB__62 BLB__61 BLB__60 BLB__59 BLB__58 BLB__57 BLB__56 BLB__55 BLB__54
+  BLB__53 BLB__52 BLB__51 BLB__50 BLB__49 BLB__48 GDL_63 GDL_62 GDL_61 GDL_60
+  GDL_59 GDL_58 GDL_57 GDL_56 GDL_55 GDL_54 GDL_53 GDL_52 GDL_51 GDL_50
+  GDL_49 GDL_48 PG1_63 PG1_62 PG1_61 PG1_60 PG1_59 PG1_58 PG1_57 PG1_56
+  PG1_55 PG1_54 PG1_53 PG1_52 PG1_51 PG1_50 PG1_49 PG1_48 PG2_63 PG2_62
+  PG2_61 PG2_60 PG2_59 PG2_58 PG2_57 PG2_56 PG2_55 PG2_54 PG2_53 PG2_52
+  PG2_51 PG2_50 PG2_49 PG2_48 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI5_0 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73
+  BLA_74 BLA_75 BLA_76 BLA_77 BLA_78 BLA_79 BLA__64 BLA__65 BLA__66 BLA__67
+  BLA__68 BLA__69 BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76
+  BLA__77 BLA__78 BLA__79 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70
+  BLB_71 BLB_72 BLB_73 BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB__64
+  BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73
+  BLB__74 BLB__75 BLB__76 BLB__77 BLB__78 BLB__79 GDL_64 GDL_65 GDL_66 GDL_67
+  GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77
+  GDL_78 GDL_79 PG1_64 PG1_65 PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71
+  PG1_72 PG1_73 PG1_74 PG1_75 PG1_76 PG1_77 PG1_78 PG1_79 PG2_64 PG2_65
+  PG2_66 PG2_67 PG2_68 PG2_69 PG2_70 PG2_71 PG2_72 PG2_73 PG2_74 PG2_75
+  PG2_76 PG2_77 PG2_78 PG2_79 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI6_0 BLA_95 BLA_94 BLA_93 BLA_92 BLA_91 BLA_90 BLA_89 BLA_88 BLA_87 BLA_86
+  BLA_85 BLA_84 BLA_83 BLA_82 BLA_81 BLA_80 BLA__95 BLA__94 BLA__93 BLA__92
+  BLA__91 BLA__90 BLA__89 BLA__88 BLA__87 BLA__86 BLA__85 BLA__84 BLA__83
+  BLA__82 BLA__81 BLA__80 BLB_95 BLB_94 BLB_93 BLB_92 BLB_91 BLB_90 BLB_89
+  BLB_88 BLB_87 BLB_86 BLB_85 BLB_84 BLB_83 BLB_82 BLB_81 BLB_80 BLB__95
+  BLB__94 BLB__93 BLB__92 BLB__91 BLB__90 BLB__89 BLB__88 BLB__87 BLB__86
+  BLB__85 BLB__84 BLB__83 BLB__82 BLB__81 BLB__80 GDL_95 GDL_94 GDL_93 GDL_92
+  GDL_91 GDL_90 GDL_89 GDL_88 GDL_87 GDL_86 GDL_85 GDL_84 GDL_83 GDL_82
+  GDL_81 GDL_80 PG1_95 PG1_94 PG1_93 PG1_92 PG1_91 PG1_90 PG1_89 PG1_88
+  PG1_87 PG1_86 PG1_85 PG1_84 PG1_83 PG1_82 PG1_81 PG1_80 PG2_95 PG2_94
+  PG2_93 PG2_92 PG2_91 PG2_90 PG2_89 PG2_88 PG2_87 PG2_86 PG2_85 PG2_84
+  PG2_83 PG2_82 PG2_81 PG2_80 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI7_0 BLA_96 BLA_97 BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104
+  BLA_105 BLA_106 BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA__96 BLA__97
+  BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104 BLA__105
+  BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLB_96 BLB_97 BLB_98
+  BLB_99 BLB_100 BLB_101 BLB_102 BLB_103 BLB_104 BLB_105 BLB_106 BLB_107
+  BLB_108 BLB_109 BLB_110 BLB_111 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100
+  BLB__101 BLB__102 BLB__103 BLB__104 BLB__105 BLB__106 BLB__107 BLB__108
+  BLB__109 BLB__110 BLB__111 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101
+  GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110
+  GDL_111 PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101 PG1_102 PG1_103 PG1_104
+  PG1_105 PG1_106 PG1_107 PG1_108 PG1_109 PG1_110 PG1_111 PG2_96 PG2_97
+  PG2_98 PG2_99 PG2_100 PG2_101 PG2_102 PG2_103 PG2_104 PG2_105 PG2_106
+  PG2_107 PG2_108 PG2_109 PG2_110 PG2_111 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0
+  WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12
+  WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22
+  WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32
+  WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42
+  WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52
+  WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62
+  WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10
+  WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20
+  WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30
+  WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40
+  WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50
+  WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60
+  WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI8_0 BLA_127 BLA_126 BLA_125 BLA_124 BLA_123 BLA_122 BLA_121 BLA_120 BLA_119
+  BLA_118 BLA_117 BLA_116 BLA_115 BLA_114 BLA_113 BLA_112 BLA__127 BLA__126
+  BLA__125 BLA__124 BLA__123 BLA__122 BLA__121 BLA__120 BLA__119 BLA__118
+  BLA__117 BLA__116 BLA__115 BLA__114 BLA__113 BLA__112 BLB_127 BLB_126
+  BLB_125 BLB_124 BLB_123 BLB_122 BLB_121 BLB_120 BLB_119 BLB_118 BLB_117
+  BLB_116 BLB_115 BLB_114 BLB_113 BLB_112 BLB__127 BLB__126 BLB__125 BLB__124
+  BLB__123 BLB__122 BLB__121 BLB__120 BLB__119 BLB__118 BLB__117 BLB__116
+  BLB__115 BLB__114 BLB__113 BLB__112 GDL_127 GDL_126 GDL_125 GDL_124 GDL_123
+  GDL_122 GDL_121 GDL_120 GDL_119 GDL_118 GDL_117 GDL_116 GDL_115 GDL_114
+  GDL_113 GDL_112 PG1_127 PG1_126 PG1_125 PG1_124 PG1_123 PG1_122 PG1_121
+  PG1_120 PG1_119 PG1_118 PG1_117 PG1_116 PG1_115 PG1_114 PG1_113 PG1_112
+  PG2_127 PG2_126 PG2_125 PG2_124 PG2_123 PG2_122 PG2_121 PG2_120 PG2_119
+  PG2_118 PG2_117 PG2_116 PG2_115 PG2_114 PG2_113 PG2_112 TIEHI_0 TIEHI_1
+  TIELO TIELO WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_COL_B
.ENDS pe_spad_1024x16_dpCORE_ARRAY_L_B
****
.SUBCKT pe_spad_1024x16_dpWD AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK
+  AX5TRACK AY0TRACK AY1TRACK BS0N BS1N BS2N BTP BTPIN0 BTPIN1 G0 G0_T G1 G1X
+  G2 G2X GTP GTPD GTPDE LGWE MGDLE MGDLS MGTPE MGTPS RBTP RBTPX RDTN RETL
+  RETR RRA0 RRA0X RRA0X_ RRA0_ RRA1 RRA1X RRA1X_ RRA1_ RREN STUBG1 STUBG2
+  TIEHI TIELO WLA0 WLA1 WLB0 WLB1 WLD0 WLD1 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7
+  XP8 XP9 XP10 XP11 XP12 XP13 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpWD: 32 flat devices **
M0 VDDPE G2 WL0PD VDDCE PCH W=0.6U L=0.06U M=1 $name=/P4/P00
M1 VDDPE G1 WL0PD VDDCE PCH W=0.6U L=0.06U M=1 $name=/P5/P00
M10 WL0I WL0PDN BTPIN0 VSSE NCH W=1.59U L=0.06U M=1 $name=/N2/N00
M11 WL0I WL0PD VSSE VSSE NCH W=0.33U L=0.06U M=1 $name=/N3/N00
M12 WL0PD G0_T NET337 VSSE NCH W=0.96U L=0.06U M=1 $name=/N10/N00
M13 WL1I WL1PD VSSE VSSE NCH W=0.33U L=0.06U M=1 $name=/tnpdkp/N00
M14 WL1I WL1PDN BTPIN1 VSSE NCH W=1.59U L=0.06U M=1 $name=/tnbtp/N00
M15 WL1PD G0 NET337 VSSE NCH W=0.96U L=0.06U M=1 $name=/N8/N00
M16 WL0PDN WL0PD VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/I6/N00
M17 VDDPE WL0PD WL0PDN VDDCE PCH W=0.15U L=0.06U M=1 $name=/I6/P00
M18 WL0N WL0I VSSE VSSE NCH W=3.2U L=0.06U M=1 $name=/I3/N00
M19 VDDCE WL0I WL0N VDDCE PCH W=5.4U L=0.06U M=1 $name=/I3/P00
M2 VDDPE G0_T WL0PD VDDCE PCH W=0.6U L=0.06U M=1 $name=/P3/P00
M20 WLD0 WL0N VSSE VSSE NCH W=8U L=0.06U M=1 $name=/I2/N00
M21 VDDCE WL0N WLD0 VDDCE PCH W=14U L=0.06U M=1 $name=/I2/P00
M22 WLD1 WL1N VSSE VSSE NCH W=8U L=0.06U M=1 $name=/gwldrv/N00
M23 VDDCE WL1N WLD1 VDDCE PCH W=14U L=0.06U M=1 $name=/gwldrv/P00
M24 WL1N WL1I VSSE VSSE NCH W=3.2U L=0.06U M=1 $name=/gpredrv/N00
M25 VDDCE WL1I WL1N VDDCE PCH W=5.4U L=0.06U M=1 $name=/gpredrv/P00
M26 WL1PDN WL1PD VSSE VSSE NCH W=0.15U L=0.06U M=1 $name=/gdrvb/N00
M27 VDDPE WL1PD WL1PDN VDDCE PCH W=0.15U L=0.06U M=1 $name=/gdrvb/P00
M28 WL0I RETL VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N1/N00
M29 WLD0 RETR VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N0/N00
M3 BTPIN0 WL0PD WL0I VDDCE PCH W=1.6U L=0.06U M=1 $name=/P0/P00
M30 WLD1 RETR VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/tnclmp/N00
M31 WL1I RETL VSSE VSSE NCH_HVT W=0.15U L=0.06U M=1 $name=/N15/N00
M4 VDDPE G1 WL1PD VDDCE PCH W=0.6U L=0.06U M=1 $name=/P1/P00
M5 VDDPE G0 WL1PD VDDCE PCH W=0.6U L=0.06U M=1 $name=/N4/P00
M6 VDDPE G2 WL1PD VDDCE PCH W=0.6U L=0.06U M=1 $name=/P2/P00
M7 BTPIN1 WL1PD WL1I VDDCE PCH W=1.6U L=0.06U M=1 $name=/tpbtp/P00
M8 NET337 G1 NET340 VSSE NCH W=0.96U L=0.06U M=1 $name=/N7/N00
M9 NET340 G2 VSSE VSSE NCH W=0.96U L=0.06U M=1 $name=/N9/N00
.ENDS pe_spad_1024x16_dpWD
****
.SUBCKT pe_spad_1024x16_dpWDSTACK_L_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK
+  AX4TRACK AX5TRACK AY0TRACK AY1TRACK BS0N BS1N BS2N BTP GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_1 RDTN RETL RETR RRA0 RRA0_ RRA1 RRA1_
+  RREN TIEHI TIELO WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7
+  WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16
+  WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25
+  WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3
+  WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13
+  WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22
+  WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31
+  WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5
+  WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15
+  WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24
+  WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 XP0 XP1 XP2 XP3 XP4
+  XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpWDSTACK_L_0: 1024 flat devices **
XI0_1 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_1 RDTN RETL RETR VSSE RRA0 RRA0_ VSSE
+  VSSE RRA1 RRA1_ VSSE RREN XP8 XP12 TIEHI TIELO WLA0_0 WLA1_0 WLB0_0 WLB1_0
+  WLA0_0 WLA1_0 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_10 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP10 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_9 WLA1_9 WLB0_9
+  WLB1_9 WLA0_9 WLA1_9 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_11 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP10 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_10 WLA1_10 WLB0_10
+  WLB1_10 WLA0_10 WLA1_10 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_12 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP10 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_11 WLA1_11 WLB0_11
+  WLB1_11 WLA0_11 WLA1_11 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_13 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP11 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP11 TIEHI TIEHI TIELO WLA0_12 WLA1_12 WLB0_12
+  WLB1_12 WLA0_12 WLA1_12 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_14 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP11 XP11 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_13 WLA1_13 WLB0_13
+  WLB1_13 WLA0_13 WLA1_13 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_15 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP11 XP11 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_14 WLA1_14 WLB0_14
+  WLB1_14 WLA0_14 WLA1_14 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_16 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP11 XP11 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_15 WLA1_15 WLB0_15
+  WLB1_15 WLA0_15 WLA1_15 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_17 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP8 XP11 XP13 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP8 XP13 TIEHI TIELO WLA0_16 WLA1_16 WLB0_16
+  WLB1_16 WLA0_16 WLA1_16 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_18 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP8 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_17 WLA1_17 WLB0_17
+  WLB1_17 WLA0_17 WLA1_17 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_19 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP8 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_18 WLA1_18 WLB0_18
+  WLB1_18 WLA0_18 WLA1_18 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_2 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_1 WLA1_1 WLB0_1
+  WLB1_1 WLA0_1 WLA1_1 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_20 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP8 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_19 WLA1_19 WLB0_19
+  WLB1_19 WLA0_19 WLA1_19 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_21 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP9 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP9 TIEHI TIEHI TIELO WLA0_20 WLA1_20 WLB0_20
+  WLB1_20 WLA0_20 WLA1_20 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_22 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP9 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_21 WLA1_21 WLB0_21
+  WLB1_21 WLA0_21 WLA1_21 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_23 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP9 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_22 WLA1_22 WLB0_22
+  WLB1_22 WLA0_22 WLA1_22 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_24 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP9 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_23 WLA1_23 WLB0_23
+  WLB1_23 WLA0_23 WLA1_23 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_25 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP10 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP10 TIEHI TIEHI TIELO WLA0_24 WLA1_24 WLB0_24
+  WLB1_24 WLA0_24 WLA1_24 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_26 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP10 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_25 WLA1_25 WLB0_25
+  WLB1_25 WLA0_25 WLA1_25 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_27 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP10 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_26 WLA1_26 WLB0_26
+  WLB1_26 WLA0_26 WLA1_26 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_28 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP10 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_27 WLA1_27 WLB0_27
+  WLB1_27 WLA0_27 WLA1_27 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_29 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP11 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP11 TIEHI TIEHI TIELO WLA0_28 WLA1_28 WLB0_28
+  WLB1_28 WLA0_28 WLA1_28 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_3 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_2 WLA1_2 WLB0_2
+  WLB1_2 WLA0_2 WLA1_2 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_30 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP11 XP11 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_29 WLA1_29 WLB0_29
+  WLB1_29 WLA0_29 WLA1_29 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_31 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP11 XP11 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_30 WLA1_30 WLB0_30
+  WLB1_30 WLA0_30 WLA1_30 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_32 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP11 XP11 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_31 WLA1_31 WLB0_31
+  WLB1_31 WLA0_31 WLA1_31 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_3 WLA1_3 WLB0_3
+  WLB1_3 WLA0_3 WLA1_3 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_5 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP9 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP9 TIEHI TIEHI TIELO WLA0_4 WLA1_4 WLB0_4 WLB1_4
+  WLA0_4 WLA1_4 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_6 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP9 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_5 WLA1_5 WLB0_5
+  WLB1_5 WLA0_5 WLA1_5 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_7 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP9 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_6 WLA1_6 WLB0_6
+  WLB1_6 WLA0_6 WLA1_6 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_8 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP9 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_7 WLA1_7 WLB0_7
+  WLB1_7 WLA0_7 WLA1_7 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_9 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP10 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP10 TIEHI TIEHI TIELO WLA0_8 WLA1_8 WLB0_8 WLB1_8
+  WLA0_8 WLA1_8 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
.ENDS pe_spad_1024x16_dpWDSTACK_L_0
****
.SUBCKT pe_spad_1024x16_dpWDSTACK_R_0 AX0TRACK AX1TRACK AX2TRACK AX3TRACK
+  AX4TRACK AX5TRACK AY0TRACK AY1TRACK BS0N BS1N BS2N BTP GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_1 RDTN RETL RETR RRA0 RRA0_ RRA1 RRA1_
+  RREN TIEHI TIELO WLA0_0 WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7
+  WLA0_8 WLA0_9 WLA0_10 WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA0_15 WLA0_16
+  WLA0_17 WLA0_18 WLA0_19 WLA0_20 WLA0_21 WLA0_22 WLA0_23 WLA0_24 WLA0_25
+  WLA0_26 WLA0_27 WLA0_28 WLA0_29 WLA0_30 WLA0_31 WLA1_0 WLA1_1 WLA1_2 WLA1_3
+  WLA1_4 WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13
+  WLA1_14 WLA1_15 WLA1_16 WLA1_17 WLA1_18 WLA1_19 WLA1_20 WLA1_21 WLA1_22
+  WLA1_23 WLA1_24 WLA1_25 WLA1_26 WLA1_27 WLA1_28 WLA1_29 WLA1_30 WLA1_31
+  WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB0_15 WLB0_16 WLB0_17 WLB0_18
+  WLB0_19 WLB0_20 WLB0_21 WLB0_22 WLB0_23 WLB0_24 WLB0_25 WLB0_26 WLB0_27
+  WLB0_28 WLB0_29 WLB0_30 WLB0_31 WLB1_0 WLB1_1 WLB1_2 WLB1_3 WLB1_4 WLB1_5
+  WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13 WLB1_14 WLB1_15
+  WLB1_16 WLB1_17 WLB1_18 WLB1_19 WLB1_20 WLB1_21 WLB1_22 WLB1_23 WLB1_24
+  WLB1_25 WLB1_26 WLB1_27 WLB1_28 WLB1_29 WLB1_30 WLB1_31 XP0 XP1 XP2 XP3 XP4
+  XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpWDSTACK_R_0: 1024 flat devices **
XI0_1 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_1 RDTN RETL RETR VSSE RRA0 RRA0_ VSSE
+  VSSE RRA1 RRA1_ VSSE RREN XP8 XP12 TIEHI TIELO WLA0_0 WLA1_0 WLB0_0 WLB1_0
+  WLB0_0 WLB1_0 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_10 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP10 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_9 WLA1_9 WLB0_9
+  WLB1_9 WLB0_9 WLB1_9 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_11 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP10 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_10 WLA1_10 WLB0_10
+  WLB1_10 WLB0_10 WLB1_10 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_12 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP10 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_11 WLA1_11 WLB0_11
+  WLB1_11 WLB0_11 WLB1_11 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_13 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP11 XP10 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP11 TIEHI TIEHI TIELO WLA0_12 WLA1_12 WLB0_12
+  WLB1_12 WLB0_12 WLB1_12 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_14 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP11 XP11 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_13 WLA1_13 WLB0_13
+  WLB1_13 WLB0_13 WLB1_13 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_15 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP11 XP11 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_14 WLA1_14 WLB0_14
+  WLB1_14 WLB0_14 WLB1_14 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_16 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP11 XP11 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_15 WLA1_15 WLB0_15
+  WLB1_15 WLB0_15 WLB1_15 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_17 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP8 XP11 XP13 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP8 XP13 TIEHI TIELO WLA0_16 WLA1_16 WLB0_16
+  WLB1_16 WLB0_16 WLB1_16 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_18 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP8 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_17 WLA1_17 WLB0_17
+  WLB1_17 WLB0_17 WLB1_17 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_19 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP8 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_18 WLA1_18 WLB0_18
+  WLB1_18 WLB0_18 WLB1_18 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_2 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_1 WLA1_1 WLB0_1
+  WLB1_1 WLB0_1 WLB1_1 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_20 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP8 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_19 WLA1_19 WLB0_19
+  WLB1_19 WLB0_19 WLB1_19 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_21 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP9 XP8 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP9 TIEHI TIEHI TIELO WLA0_20 WLA1_20 WLB0_20
+  WLB1_20 WLB0_20 WLB1_20 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_22 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP9 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_21 WLA1_21 WLB0_21
+  WLB1_21 WLB0_21 WLB1_21 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_23 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP9 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_22 WLA1_22 WLB0_22
+  WLB1_22 WLB0_22 WLB1_22 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_24 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP9 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_23 WLA1_23 WLB0_23
+  WLB1_23 WLB0_23 WLB1_23 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_25 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP10 XP9 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP10 TIEHI TIEHI TIELO WLA0_24 WLA1_24 WLB0_24
+  WLB1_24 WLB0_24 WLB1_24 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_26 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP10 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_25 WLA1_25 WLB0_25
+  WLB1_25 WLB0_25 WLB1_25 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_27 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP10 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_26 WLA1_26 WLB0_26
+  WLB1_26 WLB0_26 WLB1_26 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_28 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP10 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_27 WLA1_27 WLB0_27
+  WLB1_27 WLB0_27 WLB1_27 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_29 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP11 XP10 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP11 TIEHI TIEHI TIELO WLA0_28 WLA1_28 WLB0_28
+  WLB1_28 WLB0_28 WLB1_28 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_3 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_2 WLA1_2 WLB0_2
+  WLB1_2 WLB0_2 WLB1_2 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_30 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP11 XP11 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_29 WLA1_29 WLB0_29
+  WLB1_29 WLB0_29 WLB1_29 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_31 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP11 XP11 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_30 WLA1_30 WLB0_30
+  WLB1_30 WLB0_30 WLB1_30 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_32 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP11 XP11 XP13 XP13 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_31 WLA1_31 WLB0_31
+  WLB1_31 WLB0_31 WLB1_31 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11
+  XP12 XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_4 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP8 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_3 WLA1_3 WLB0_3
+  WLB1_3 WLB0_3 WLB1_3 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_5 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP9 XP8 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP9 TIEHI TIEHI TIELO WLA0_4 WLA1_4 WLB0_4 WLB1_4
+  WLB0_4 WLB1_4 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_6 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP3 XP2 XP9 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_5 WLA1_5 WLB0_5
+  WLB1_5 WLB0_5 WLB1_5 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_7 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP4 XP5 XP9 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_6 WLA1_6 WLB0_6
+  WLB1_6 WLB0_6 WLB1_6 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_8 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP7 XP6 XP9 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN TIEHI TIEHI TIEHI TIELO WLA0_7 WLA1_7 WLB0_7
+  WLB1_7 WLB0_7 WLB1_7 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12
+  XP13 VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
XI0_9 AX0TRACK AX1TRACK AX2TRACK AX3TRACK AX4TRACK AX5TRACK AY0TRACK AY1TRACK
+  BS0N BS1N BS2N BTP BTP BTP XP0 XP1 XP10 XP9 XP12 XP12 GTP GTPD GTPDE LGWE
+  MGDLE MGDLS MGTPE MGTPS RBTP_0 RBTP_0 RDTN RETL RETR VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE RREN XP10 TIEHI TIEHI TIELO WLA0_8 WLA1_8 WLB0_8 WLB1_8
+  WLB0_8 WLB1_8 XP0 XP1 XP2 XP3 XP4 XP5 XP6 XP7 XP8 XP9 XP10 XP11 XP12 XP13
+  VDDPE VDDCE VSSE pe_spad_1024x16_dpWD
.ENDS pe_spad_1024x16_dpWDSTACK_R_0
****
.SUBCKT pe_spad_1024x16_dpCORE_ARRAY_R_B BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5
+  BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16
+  BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26
+  BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36
+  BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46
+  BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56
+  BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66
+  BLA_67 BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76
+  BLA_77 BLA_78 BLA_79 BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86
+  BLA_87 BLA_88 BLA_89 BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96
+  BLA_97 BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105
+  BLA_106 BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114
+  BLA_115 BLA_116 BLA_117 BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123
+  BLA_124 BLA_125 BLA_126 BLA_127 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5
+  BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78
+  BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87
+  BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96
+  BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104
+  BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112
+  BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120
+  BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLB_0 BLB_1
+  BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13
+  BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23
+  BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33
+  BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43
+  BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53
+  BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63
+  BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71 BLB_72 BLB_73
+  BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81 BLB_82 BLB_83
+  BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91 BLB_92 BLB_93
+  BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101 BLB_102 BLB_103
+  BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110 BLB_111 BLB_112
+  BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119 BLB_120 BLB_121
+  BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB__0 BLB__1 BLB__2 BLB__3
+  BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13
+  BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22
+  BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31
+  BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40
+  BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49
+  BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58
+  BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67
+  BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73 BLB__74 BLB__75 BLB__76
+  BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82 BLB__83 BLB__84 BLB__85
+  BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91 BLB__92 BLB__93 BLB__94
+  BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100 BLB__101 BLB__102 BLB__103
+  BLB__104 BLB__105 BLB__106 BLB__107 BLB__108 BLB__109 BLB__110 BLB__111
+  BLB__112 BLB__113 BLB__114 BLB__115 BLB__116 BLB__117 BLB__118 BLB__119
+  BLB__120 BLB__121 BLB__122 BLB__123 BLB__124 BLB__125 BLB__126 BLB__127
+  GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11
+  GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21
+  GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31
+  GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41
+  GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51
+  GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61
+  GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71
+  GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81
+  GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91
+  GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101
+  GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110
+  GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119
+  GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 MBL PG1_0
+  PG1_1 PG1_2 PG1_3 PG1_4 PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12
+  PG1_13 PG1_14 PG1_15 PG1_16 PG1_17 PG1_18 PG1_19 PG1_20 PG1_21 PG1_22
+  PG1_23 PG1_24 PG1_25 PG1_26 PG1_27 PG1_28 PG1_29 PG1_30 PG1_31 PG1_32
+  PG1_33 PG1_34 PG1_35 PG1_36 PG1_37 PG1_38 PG1_39 PG1_40 PG1_41 PG1_42
+  PG1_43 PG1_44 PG1_45 PG1_46 PG1_47 PG1_48 PG1_49 PG1_50 PG1_51 PG1_52
+  PG1_53 PG1_54 PG1_55 PG1_56 PG1_57 PG1_58 PG1_59 PG1_60 PG1_61 PG1_62
+  PG1_63 PG1_64 PG1_65 PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71 PG1_72
+  PG1_73 PG1_74 PG1_75 PG1_76 PG1_77 PG1_78 PG1_79 PG1_80 PG1_81 PG1_82
+  PG1_83 PG1_84 PG1_85 PG1_86 PG1_87 PG1_88 PG1_89 PG1_90 PG1_91 PG1_92
+  PG1_93 PG1_94 PG1_95 PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101 PG1_102
+  PG1_103 PG1_104 PG1_105 PG1_106 PG1_107 PG1_108 PG1_109 PG1_110 PG1_111
+  PG1_112 PG1_113 PG1_114 PG1_115 PG1_116 PG1_117 PG1_118 PG1_119 PG1_120
+  PG1_121 PG1_122 PG1_123 PG1_124 PG1_125 PG1_126 PG1_127 PG2_0 PG2_1 PG2_2
+  PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12 PG2_13
+  PG2_14 PG2_15 PG2_16 PG2_17 PG2_18 PG2_19 PG2_20 PG2_21 PG2_22 PG2_23
+  PG2_24 PG2_25 PG2_26 PG2_27 PG2_28 PG2_29 PG2_30 PG2_31 PG2_32 PG2_33
+  PG2_34 PG2_35 PG2_36 PG2_37 PG2_38 PG2_39 PG2_40 PG2_41 PG2_42 PG2_43
+  PG2_44 PG2_45 PG2_46 PG2_47 PG2_48 PG2_49 PG2_50 PG2_51 PG2_52 PG2_53
+  PG2_54 PG2_55 PG2_56 PG2_57 PG2_58 PG2_59 PG2_60 PG2_61 PG2_62 PG2_63
+  PG2_64 PG2_65 PG2_66 PG2_67 PG2_68 PG2_69 PG2_70 PG2_71 PG2_72 PG2_73
+  PG2_74 PG2_75 PG2_76 PG2_77 PG2_78 PG2_79 PG2_80 PG2_81 PG2_82 PG2_83
+  PG2_84 PG2_85 PG2_86 PG2_87 PG2_88 PG2_89 PG2_90 PG2_91 PG2_92 PG2_93
+  PG2_94 PG2_95 PG2_96 PG2_97 PG2_98 PG2_99 PG2_100 PG2_101 PG2_102 PG2_103
+  PG2_104 PG2_105 PG2_106 PG2_107 PG2_108 PG2_109 PG2_110 PG2_111 PG2_112
+  PG2_113 PG2_114 PG2_115 PG2_116 PG2_117 PG2_118 PG2_119 PG2_120 PG2_121
+  PG2_122 PG2_123 PG2_124 PG2_125 PG2_126 PG2_127 TIEHI_0 TIEHI_1 TIELO WLA_0
+  WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12
+  WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22
+  WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32
+  WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42
+  WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52
+  WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62
+  WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10
+  WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20
+  WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30
+  WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40
+  WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50
+  WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60
+  WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpCORE_ARRAY_R_B: 66048 flat devices **
XI0_0 MBL TIEHI_0 TIEHI_1 TIELO WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCCMBL_COL_0
XI1_0 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10
+  BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10
+  BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5
+  PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11 PG1_12 PG1_13 PG1_14 PG1_15 PG2_0
+  PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10 PG2_11 PG2_12
+  PG2_13 PG2_14 PG2_15 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34
+  WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44
+  WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54
+  WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1
+  WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33
+  WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43
+  WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53
+  WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE
+  VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI2_0 BLA_31 BLA_30 BLA_29 BLA_28 BLA_27 BLA_26 BLA_25 BLA_24 BLA_23 BLA_22
+  BLA_21 BLA_20 BLA_19 BLA_18 BLA_17 BLA_16 BLA__31 BLA__30 BLA__29 BLA__28
+  BLA__27 BLA__26 BLA__25 BLA__24 BLA__23 BLA__22 BLA__21 BLA__20 BLA__19
+  BLA__18 BLA__17 BLA__16 BLB_31 BLB_30 BLB_29 BLB_28 BLB_27 BLB_26 BLB_25
+  BLB_24 BLB_23 BLB_22 BLB_21 BLB_20 BLB_19 BLB_18 BLB_17 BLB_16 BLB__31
+  BLB__30 BLB__29 BLB__28 BLB__27 BLB__26 BLB__25 BLB__24 BLB__23 BLB__22
+  BLB__21 BLB__20 BLB__19 BLB__18 BLB__17 BLB__16 GDL_31 GDL_30 GDL_29 GDL_28
+  GDL_27 GDL_26 GDL_25 GDL_24 GDL_23 GDL_22 GDL_21 GDL_20 GDL_19 GDL_18
+  GDL_17 GDL_16 PG1_31 PG1_30 PG1_29 PG1_28 PG1_27 PG1_26 PG1_25 PG1_24
+  PG1_23 PG1_22 PG1_21 PG1_20 PG1_19 PG1_18 PG1_17 PG1_16 PG2_31 PG2_30
+  PG2_29 PG2_28 PG2_27 PG2_26 PG2_25 PG2_24 PG2_23 PG2_22 PG2_21 PG2_20
+  PG2_19 PG2_18 PG2_17 PG2_16 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI3_0 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39 BLA_40 BLA_41
+  BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA__32 BLA__33 BLA__34 BLA__35
+  BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42 BLA__43 BLA__44
+  BLA__45 BLA__46 BLA__47 BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38
+  BLB_39 BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB__32
+  BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41
+  BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 PG1_32 PG1_33 PG1_34 PG1_35 PG1_36 PG1_37 PG1_38 PG1_39
+  PG1_40 PG1_41 PG1_42 PG1_43 PG1_44 PG1_45 PG1_46 PG1_47 PG2_32 PG2_33
+  PG2_34 PG2_35 PG2_36 PG2_37 PG2_38 PG2_39 PG2_40 PG2_41 PG2_42 PG2_43
+  PG2_44 PG2_45 PG2_46 PG2_47 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI4_0 BLA_63 BLA_62 BLA_61 BLA_60 BLA_59 BLA_58 BLA_57 BLA_56 BLA_55 BLA_54
+  BLA_53 BLA_52 BLA_51 BLA_50 BLA_49 BLA_48 BLA__63 BLA__62 BLA__61 BLA__60
+  BLA__59 BLA__58 BLA__57 BLA__56 BLA__55 BLA__54 BLA__53 BLA__52 BLA__51
+  BLA__50 BLA__49 BLA__48 BLB_63 BLB_62 BLB_61 BLB_60 BLB_59 BLB_58 BLB_57
+  BLB_56 BLB_55 BLB_54 BLB_53 BLB_52 BLB_51 BLB_50 BLB_49 BLB_48 BLB__63
+  BLB__62 BLB__61 BLB__60 BLB__59 BLB__58 BLB__57 BLB__56 BLB__55 BLB__54
+  BLB__53 BLB__52 BLB__51 BLB__50 BLB__49 BLB__48 GDL_63 GDL_62 GDL_61 GDL_60
+  GDL_59 GDL_58 GDL_57 GDL_56 GDL_55 GDL_54 GDL_53 GDL_52 GDL_51 GDL_50
+  GDL_49 GDL_48 PG1_63 PG1_62 PG1_61 PG1_60 PG1_59 PG1_58 PG1_57 PG1_56
+  PG1_55 PG1_54 PG1_53 PG1_52 PG1_51 PG1_50 PG1_49 PG1_48 PG2_63 PG2_62
+  PG2_61 PG2_60 PG2_59 PG2_58 PG2_57 PG2_56 PG2_55 PG2_54 PG2_53 PG2_52
+  PG2_51 PG2_50 PG2_49 PG2_48 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI5_0 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69 BLA_70 BLA_71 BLA_72 BLA_73
+  BLA_74 BLA_75 BLA_76 BLA_77 BLA_78 BLA_79 BLA__64 BLA__65 BLA__66 BLA__67
+  BLA__68 BLA__69 BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76
+  BLA__77 BLA__78 BLA__79 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70
+  BLB_71 BLB_72 BLB_73 BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB__64
+  BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73
+  BLB__74 BLB__75 BLB__76 BLB__77 BLB__78 BLB__79 GDL_64 GDL_65 GDL_66 GDL_67
+  GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77
+  GDL_78 GDL_79 PG1_64 PG1_65 PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71
+  PG1_72 PG1_73 PG1_74 PG1_75 PG1_76 PG1_77 PG1_78 PG1_79 PG2_64 PG2_65
+  PG2_66 PG2_67 PG2_68 PG2_69 PG2_70 PG2_71 PG2_72 PG2_73 PG2_74 PG2_75
+  PG2_76 PG2_77 PG2_78 PG2_79 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI6_0 BLA_95 BLA_94 BLA_93 BLA_92 BLA_91 BLA_90 BLA_89 BLA_88 BLA_87 BLA_86
+  BLA_85 BLA_84 BLA_83 BLA_82 BLA_81 BLA_80 BLA__95 BLA__94 BLA__93 BLA__92
+  BLA__91 BLA__90 BLA__89 BLA__88 BLA__87 BLA__86 BLA__85 BLA__84 BLA__83
+  BLA__82 BLA__81 BLA__80 BLB_95 BLB_94 BLB_93 BLB_92 BLB_91 BLB_90 BLB_89
+  BLB_88 BLB_87 BLB_86 BLB_85 BLB_84 BLB_83 BLB_82 BLB_81 BLB_80 BLB__95
+  BLB__94 BLB__93 BLB__92 BLB__91 BLB__90 BLB__89 BLB__88 BLB__87 BLB__86
+  BLB__85 BLB__84 BLB__83 BLB__82 BLB__81 BLB__80 GDL_95 GDL_94 GDL_93 GDL_92
+  GDL_91 GDL_90 GDL_89 GDL_88 GDL_87 GDL_86 GDL_85 GDL_84 GDL_83 GDL_82
+  GDL_81 GDL_80 PG1_95 PG1_94 PG1_93 PG1_92 PG1_91 PG1_90 PG1_89 PG1_88
+  PG1_87 PG1_86 PG1_85 PG1_84 PG1_83 PG1_82 PG1_81 PG1_80 PG2_95 PG2_94
+  PG2_93 PG2_92 PG2_91 PG2_90 PG2_89 PG2_88 PG2_87 PG2_86 PG2_85 PG2_84
+  PG2_83 PG2_82 PG2_81 PG2_80 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0 WLA_1 WLA_2
+  WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33
+  WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43
+  WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53
+  WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32
+  WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42
+  WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52
+  WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62
+  WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI7_0 BLA_96 BLA_97 BLA_98 BLA_99 BLA_100 BLA_101 BLA_102 BLA_103 BLA_104
+  BLA_105 BLA_106 BLA_107 BLA_108 BLA_109 BLA_110 BLA_111 BLA__96 BLA__97
+  BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104 BLA__105
+  BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLB_96 BLB_97 BLB_98
+  BLB_99 BLB_100 BLB_101 BLB_102 BLB_103 BLB_104 BLB_105 BLB_106 BLB_107
+  BLB_108 BLB_109 BLB_110 BLB_111 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100
+  BLB__101 BLB__102 BLB__103 BLB__104 BLB__105 BLB__106 BLB__107 BLB__108
+  BLB__109 BLB__110 BLB__111 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101
+  GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110
+  GDL_111 PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101 PG1_102 PG1_103 PG1_104
+  PG1_105 PG1_106 PG1_107 PG1_108 PG1_109 PG1_110 PG1_111 PG2_96 PG2_97
+  PG2_98 PG2_99 PG2_100 PG2_101 PG2_102 PG2_103 PG2_104 PG2_105 PG2_106
+  PG2_107 PG2_108 PG2_109 PG2_110 PG2_111 TIEHI_0 TIEHI_1 TIELO TIELO WLA_0
+  WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12
+  WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22
+  WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLA_31 WLA_32
+  WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39 WLA_40 WLA_41 WLA_42
+  WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49 WLA_50 WLA_51 WLA_52
+  WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59 WLA_60 WLA_61 WLA_62
+  WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10
+  WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20
+  WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30
+  WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38 WLB_39 WLB_40
+  WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48 WLB_49 WLB_50
+  WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58 WLB_59 WLB_60
+  WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE pe_spad_1024x16_dpBIT_COL_B
XI8_0 BLA_127 BLA_126 BLA_125 BLA_124 BLA_123 BLA_122 BLA_121 BLA_120 BLA_119
+  BLA_118 BLA_117 BLA_116 BLA_115 BLA_114 BLA_113 BLA_112 BLA__127 BLA__126
+  BLA__125 BLA__124 BLA__123 BLA__122 BLA__121 BLA__120 BLA__119 BLA__118
+  BLA__117 BLA__116 BLA__115 BLA__114 BLA__113 BLA__112 BLB_127 BLB_126
+  BLB_125 BLB_124 BLB_123 BLB_122 BLB_121 BLB_120 BLB_119 BLB_118 BLB_117
+  BLB_116 BLB_115 BLB_114 BLB_113 BLB_112 BLB__127 BLB__126 BLB__125 BLB__124
+  BLB__123 BLB__122 BLB__121 BLB__120 BLB__119 BLB__118 BLB__117 BLB__116
+  BLB__115 BLB__114 BLB__113 BLB__112 GDL_127 GDL_126 GDL_125 GDL_124 GDL_123
+  GDL_122 GDL_121 GDL_120 GDL_119 GDL_118 GDL_117 GDL_116 GDL_115 GDL_114
+  GDL_113 GDL_112 PG1_127 PG1_126 PG1_125 PG1_124 PG1_123 PG1_122 PG1_121
+  PG1_120 PG1_119 PG1_118 PG1_117 PG1_116 PG1_115 PG1_114 PG1_113 PG1_112
+  PG2_127 PG2_126 PG2_125 PG2_124 PG2_123 PG2_122 PG2_121 PG2_120 PG2_119
+  PG2_118 PG2_117 PG2_116 PG2_115 PG2_114 PG2_113 PG2_112 TIEHI_0 TIEHI_1
+  TIELO TIELO WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37 WLA_38 WLA_39
+  WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47 WLA_48 WLA_49
+  WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57 WLA_58 WLA_59
+  WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35 WLB_36 WLB_37 WLB_38
+  WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45 WLB_46 WLB_47 WLB_48
+  WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55 WLB_56 WLB_57 WLB_58
+  WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpBIT_COL_B
.ENDS pe_spad_1024x16_dpCORE_ARRAY_R_B
****
.SUBCKT pe_spad_1024x16_dpBANK_ARRAY_0 AX0TRACK_0 AX0TRACK_1 AX1TRACK_0
+  AX1TRACK_1 AX2TRACK_0 AX2TRACK_1 AX3TRACK_0 AX3TRACK_1 AX4TRACK_0
+  AX4TRACK_1 AX5TRACK_0 AX5TRACK_1 AY0TRACK_0 AY0TRACK_1 AY1TRACK_0
+  AY1TRACK_1 BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9
+  BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17 BLA_18 BLA_19
+  BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27 BLA_28 BLA_29
+  BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39
+  BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA_48 BLA_49
+  BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57 BLA_58 BLA_59
+  BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69
+  BLA_70 BLA_71 BLA_72 BLA_73 BLA_74 BLA_75 BLA_76 BLA_77 BLA_78 BLA_79
+  BLA_80 BLA_81 BLA_82 BLA_83 BLA_84 BLA_85 BLA_86 BLA_87 BLA_88 BLA_89
+  BLA_90 BLA_91 BLA_92 BLA_93 BLA_94 BLA_95 BLA_96 BLA_97 BLA_98 BLA_99
+  BLA_100 BLA_101 BLA_102 BLA_103 BLA_104 BLA_105 BLA_106 BLA_107 BLA_108
+  BLA_109 BLA_110 BLA_111 BLA_112 BLA_113 BLA_114 BLA_115 BLA_116 BLA_117
+  BLA_118 BLA_119 BLA_120 BLA_121 BLA_122 BLA_123 BLA_124 BLA_125 BLA_126
+  BLA_127 BLA_128 BLA_129 BLA_130 BLA_131 BLA_132 BLA_133 BLA_134 BLA_135
+  BLA_136 BLA_137 BLA_138 BLA_139 BLA_140 BLA_141 BLA_142 BLA_143 BLA_144
+  BLA_145 BLA_146 BLA_147 BLA_148 BLA_149 BLA_150 BLA_151 BLA_152 BLA_153
+  BLA_154 BLA_155 BLA_156 BLA_157 BLA_158 BLA_159 BLA_160 BLA_161 BLA_162
+  BLA_163 BLA_164 BLA_165 BLA_166 BLA_167 BLA_168 BLA_169 BLA_170 BLA_171
+  BLA_172 BLA_173 BLA_174 BLA_175 BLA_176 BLA_177 BLA_178 BLA_179 BLA_180
+  BLA_181 BLA_182 BLA_183 BLA_184 BLA_185 BLA_186 BLA_187 BLA_188 BLA_189
+  BLA_190 BLA_191 BLA_192 BLA_193 BLA_194 BLA_195 BLA_196 BLA_197 BLA_198
+  BLA_199 BLA_200 BLA_201 BLA_202 BLA_203 BLA_204 BLA_205 BLA_206 BLA_207
+  BLA_208 BLA_209 BLA_210 BLA_211 BLA_212 BLA_213 BLA_214 BLA_215 BLA_216
+  BLA_217 BLA_218 BLA_219 BLA_220 BLA_221 BLA_222 BLA_223 BLA_224 BLA_225
+  BLA_226 BLA_227 BLA_228 BLA_229 BLA_230 BLA_231 BLA_232 BLA_233 BLA_234
+  BLA_235 BLA_236 BLA_237 BLA_238 BLA_239 BLA_240 BLA_241 BLA_242 BLA_243
+  BLA_244 BLA_245 BLA_246 BLA_247 BLA_248 BLA_249 BLA_250 BLA_251 BLA_252
+  BLA_253 BLA_254 BLA_255 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5 BLA__6
+  BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLA__71 BLA__72 BLA__73 BLA__74 BLA__75 BLA__76 BLA__77 BLA__78
+  BLA__79 BLA__80 BLA__81 BLA__82 BLA__83 BLA__84 BLA__85 BLA__86 BLA__87
+  BLA__88 BLA__89 BLA__90 BLA__91 BLA__92 BLA__93 BLA__94 BLA__95 BLA__96
+  BLA__97 BLA__98 BLA__99 BLA__100 BLA__101 BLA__102 BLA__103 BLA__104
+  BLA__105 BLA__106 BLA__107 BLA__108 BLA__109 BLA__110 BLA__111 BLA__112
+  BLA__113 BLA__114 BLA__115 BLA__116 BLA__117 BLA__118 BLA__119 BLA__120
+  BLA__121 BLA__122 BLA__123 BLA__124 BLA__125 BLA__126 BLA__127 BLA__128
+  BLA__129 BLA__130 BLA__131 BLA__132 BLA__133 BLA__134 BLA__135 BLA__136
+  BLA__137 BLA__138 BLA__139 BLA__140 BLA__141 BLA__142 BLA__143 BLA__144
+  BLA__145 BLA__146 BLA__147 BLA__148 BLA__149 BLA__150 BLA__151 BLA__152
+  BLA__153 BLA__154 BLA__155 BLA__156 BLA__157 BLA__158 BLA__159 BLA__160
+  BLA__161 BLA__162 BLA__163 BLA__164 BLA__165 BLA__166 BLA__167 BLA__168
+  BLA__169 BLA__170 BLA__171 BLA__172 BLA__173 BLA__174 BLA__175 BLA__176
+  BLA__177 BLA__178 BLA__179 BLA__180 BLA__181 BLA__182 BLA__183 BLA__184
+  BLA__185 BLA__186 BLA__187 BLA__188 BLA__189 BLA__190 BLA__191 BLA__192
+  BLA__193 BLA__194 BLA__195 BLA__196 BLA__197 BLA__198 BLA__199 BLA__200
+  BLA__201 BLA__202 BLA__203 BLA__204 BLA__205 BLA__206 BLA__207 BLA__208
+  BLA__209 BLA__210 BLA__211 BLA__212 BLA__213 BLA__214 BLA__215 BLA__216
+  BLA__217 BLA__218 BLA__219 BLA__220 BLA__221 BLA__222 BLA__223 BLA__224
+  BLA__225 BLA__226 BLA__227 BLA__228 BLA__229 BLA__230 BLA__231 BLA__232
+  BLA__233 BLA__234 BLA__235 BLA__236 BLA__237 BLA__238 BLA__239 BLA__240
+  BLA__241 BLA__242 BLA__243 BLA__244 BLA__245 BLA__246 BLA__247 BLA__248
+  BLA__249 BLA__250 BLA__251 BLA__252 BLA__253 BLA__254 BLA__255 BLB_0 BLB_1
+  BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13
+  BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23
+  BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33
+  BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43
+  BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53
+  BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63
+  BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB_71 BLB_72 BLB_73
+  BLB_74 BLB_75 BLB_76 BLB_77 BLB_78 BLB_79 BLB_80 BLB_81 BLB_82 BLB_83
+  BLB_84 BLB_85 BLB_86 BLB_87 BLB_88 BLB_89 BLB_90 BLB_91 BLB_92 BLB_93
+  BLB_94 BLB_95 BLB_96 BLB_97 BLB_98 BLB_99 BLB_100 BLB_101 BLB_102 BLB_103
+  BLB_104 BLB_105 BLB_106 BLB_107 BLB_108 BLB_109 BLB_110 BLB_111 BLB_112
+  BLB_113 BLB_114 BLB_115 BLB_116 BLB_117 BLB_118 BLB_119 BLB_120 BLB_121
+  BLB_122 BLB_123 BLB_124 BLB_125 BLB_126 BLB_127 BLB_128 BLB_129 BLB_130
+  BLB_131 BLB_132 BLB_133 BLB_134 BLB_135 BLB_136 BLB_137 BLB_138 BLB_139
+  BLB_140 BLB_141 BLB_142 BLB_143 BLB_144 BLB_145 BLB_146 BLB_147 BLB_148
+  BLB_149 BLB_150 BLB_151 BLB_152 BLB_153 BLB_154 BLB_155 BLB_156 BLB_157
+  BLB_158 BLB_159 BLB_160 BLB_161 BLB_162 BLB_163 BLB_164 BLB_165 BLB_166
+  BLB_167 BLB_168 BLB_169 BLB_170 BLB_171 BLB_172 BLB_173 BLB_174 BLB_175
+  BLB_176 BLB_177 BLB_178 BLB_179 BLB_180 BLB_181 BLB_182 BLB_183 BLB_184
+  BLB_185 BLB_186 BLB_187 BLB_188 BLB_189 BLB_190 BLB_191 BLB_192 BLB_193
+  BLB_194 BLB_195 BLB_196 BLB_197 BLB_198 BLB_199 BLB_200 BLB_201 BLB_202
+  BLB_203 BLB_204 BLB_205 BLB_206 BLB_207 BLB_208 BLB_209 BLB_210 BLB_211
+  BLB_212 BLB_213 BLB_214 BLB_215 BLB_216 BLB_217 BLB_218 BLB_219 BLB_220
+  BLB_221 BLB_222 BLB_223 BLB_224 BLB_225 BLB_226 BLB_227 BLB_228 BLB_229
+  BLB_230 BLB_231 BLB_232 BLB_233 BLB_234 BLB_235 BLB_236 BLB_237 BLB_238
+  BLB_239 BLB_240 BLB_241 BLB_242 BLB_243 BLB_244 BLB_245 BLB_246 BLB_247
+  BLB_248 BLB_249 BLB_250 BLB_251 BLB_252 BLB_253 BLB_254 BLB_255 BLB__0
+  BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10
+  BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19
+  BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28
+  BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37
+  BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46
+  BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55
+  BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64
+  BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 BLB__71 BLB__72 BLB__73
+  BLB__74 BLB__75 BLB__76 BLB__77 BLB__78 BLB__79 BLB__80 BLB__81 BLB__82
+  BLB__83 BLB__84 BLB__85 BLB__86 BLB__87 BLB__88 BLB__89 BLB__90 BLB__91
+  BLB__92 BLB__93 BLB__94 BLB__95 BLB__96 BLB__97 BLB__98 BLB__99 BLB__100
+  BLB__101 BLB__102 BLB__103 BLB__104 BLB__105 BLB__106 BLB__107 BLB__108
+  BLB__109 BLB__110 BLB__111 BLB__112 BLB__113 BLB__114 BLB__115 BLB__116
+  BLB__117 BLB__118 BLB__119 BLB__120 BLB__121 BLB__122 BLB__123 BLB__124
+  BLB__125 BLB__126 BLB__127 BLB__128 BLB__129 BLB__130 BLB__131 BLB__132
+  BLB__133 BLB__134 BLB__135 BLB__136 BLB__137 BLB__138 BLB__139 BLB__140
+  BLB__141 BLB__142 BLB__143 BLB__144 BLB__145 BLB__146 BLB__147 BLB__148
+  BLB__149 BLB__150 BLB__151 BLB__152 BLB__153 BLB__154 BLB__155 BLB__156
+  BLB__157 BLB__158 BLB__159 BLB__160 BLB__161 BLB__162 BLB__163 BLB__164
+  BLB__165 BLB__166 BLB__167 BLB__168 BLB__169 BLB__170 BLB__171 BLB__172
+  BLB__173 BLB__174 BLB__175 BLB__176 BLB__177 BLB__178 BLB__179 BLB__180
+  BLB__181 BLB__182 BLB__183 BLB__184 BLB__185 BLB__186 BLB__187 BLB__188
+  BLB__189 BLB__190 BLB__191 BLB__192 BLB__193 BLB__194 BLB__195 BLB__196
+  BLB__197 BLB__198 BLB__199 BLB__200 BLB__201 BLB__202 BLB__203 BLB__204
+  BLB__205 BLB__206 BLB__207 BLB__208 BLB__209 BLB__210 BLB__211 BLB__212
+  BLB__213 BLB__214 BLB__215 BLB__216 BLB__217 BLB__218 BLB__219 BLB__220
+  BLB__221 BLB__222 BLB__223 BLB__224 BLB__225 BLB__226 BLB__227 BLB__228
+  BLB__229 BLB__230 BLB__231 BLB__232 BLB__233 BLB__234 BLB__235 BLB__236
+  BLB__237 BLB__238 BLB__239 BLB__240 BLB__241 BLB__242 BLB__243 BLB__244
+  BLB__245 BLB__246 BLB__247 BLB__248 BLB__249 BLB__250 BLB__251 BLB__252
+  BLB__253 BLB__254 BLB__255 BS0N_0 BS0N_1 BS1N_0 BS1N_1 BS2N_0 BS2N_1 BTP_0
+  BTP_1 GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10
+  GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20
+  GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30
+  GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40
+  GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50
+  GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60
+  GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70
+  GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80
+  GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90
+  GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100
+  GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109
+  GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118
+  GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127
+  GDL_128 GDL_129 GDL_130 GDL_131 GDL_132 GDL_133 GDL_134 GDL_135 GDL_136
+  GDL_137 GDL_138 GDL_139 GDL_140 GDL_141 GDL_142 GDL_143 GDL_144 GDL_145
+  GDL_146 GDL_147 GDL_148 GDL_149 GDL_150 GDL_151 GDL_152 GDL_153 GDL_154
+  GDL_155 GDL_156 GDL_157 GDL_158 GDL_159 GDL_160 GDL_161 GDL_162 GDL_163
+  GDL_164 GDL_165 GDL_166 GDL_167 GDL_168 GDL_169 GDL_170 GDL_171 GDL_172
+  GDL_173 GDL_174 GDL_175 GDL_176 GDL_177 GDL_178 GDL_179 GDL_180 GDL_181
+  GDL_182 GDL_183 GDL_184 GDL_185 GDL_186 GDL_187 GDL_188 GDL_189 GDL_190
+  GDL_191 GDL_192 GDL_193 GDL_194 GDL_195 GDL_196 GDL_197 GDL_198 GDL_199
+  GDL_200 GDL_201 GDL_202 GDL_203 GDL_204 GDL_205 GDL_206 GDL_207 GDL_208
+  GDL_209 GDL_210 GDL_211 GDL_212 GDL_213 GDL_214 GDL_215 GDL_216 GDL_217
+  GDL_218 GDL_219 GDL_220 GDL_221 GDL_222 GDL_223 GDL_224 GDL_225 GDL_226
+  GDL_227 GDL_228 GDL_229 GDL_230 GDL_231 GDL_232 GDL_233 GDL_234 GDL_235
+  GDL_236 GDL_237 GDL_238 GDL_239 GDL_240 GDL_241 GDL_242 GDL_243 GDL_244
+  GDL_245 GDL_246 GDL_247 GDL_248 GDL_249 GDL_250 GDL_251 GDL_252 GDL_253
+  GDL_254 GDL_255 GTPDE_0 GTPDE_1 GTPD_0 GTPD_1 GTP_0 GTP_1 LGWE_0 LGWE_1
+  MBL_0 MBL_1 MGDLE_0 MGDLE_1 MGDLS_0 MGDLS_1 MGTPE_0 MGTPE_1 MGTPS_0 MGTPS_1
+  PG1_0 PG1_1 PG1_2 PG1_3 PG1_4 PG1_5 PG1_6 PG1_7 PG1_8 PG1_9 PG1_10 PG1_11
+  PG1_12 PG1_13 PG1_14 PG1_15 PG1_16 PG1_17 PG1_18 PG1_19 PG1_20 PG1_21
+  PG1_22 PG1_23 PG1_24 PG1_25 PG1_26 PG1_27 PG1_28 PG1_29 PG1_30 PG1_31
+  PG1_32 PG1_33 PG1_34 PG1_35 PG1_36 PG1_37 PG1_38 PG1_39 PG1_40 PG1_41
+  PG1_42 PG1_43 PG1_44 PG1_45 PG1_46 PG1_47 PG1_48 PG1_49 PG1_50 PG1_51
+  PG1_52 PG1_53 PG1_54 PG1_55 PG1_56 PG1_57 PG1_58 PG1_59 PG1_60 PG1_61
+  PG1_62 PG1_63 PG1_64 PG1_65 PG1_66 PG1_67 PG1_68 PG1_69 PG1_70 PG1_71
+  PG1_72 PG1_73 PG1_74 PG1_75 PG1_76 PG1_77 PG1_78 PG1_79 PG1_80 PG1_81
+  PG1_82 PG1_83 PG1_84 PG1_85 PG1_86 PG1_87 PG1_88 PG1_89 PG1_90 PG1_91
+  PG1_92 PG1_93 PG1_94 PG1_95 PG1_96 PG1_97 PG1_98 PG1_99 PG1_100 PG1_101
+  PG1_102 PG1_103 PG1_104 PG1_105 PG1_106 PG1_107 PG1_108 PG1_109 PG1_110
+  PG1_111 PG1_112 PG1_113 PG1_114 PG1_115 PG1_116 PG1_117 PG1_118 PG1_119
+  PG1_120 PG1_121 PG1_122 PG1_123 PG1_124 PG1_125 PG1_126 PG1_127 PG1_128
+  PG1_129 PG1_130 PG1_131 PG1_132 PG1_133 PG1_134 PG1_135 PG1_136 PG1_137
+  PG1_138 PG1_139 PG1_140 PG1_141 PG1_142 PG1_143 PG1_144 PG1_145 PG1_146
+  PG1_147 PG1_148 PG1_149 PG1_150 PG1_151 PG1_152 PG1_153 PG1_154 PG1_155
+  PG1_156 PG1_157 PG1_158 PG1_159 PG1_160 PG1_161 PG1_162 PG1_163 PG1_164
+  PG1_165 PG1_166 PG1_167 PG1_168 PG1_169 PG1_170 PG1_171 PG1_172 PG1_173
+  PG1_174 PG1_175 PG1_176 PG1_177 PG1_178 PG1_179 PG1_180 PG1_181 PG1_182
+  PG1_183 PG1_184 PG1_185 PG1_186 PG1_187 PG1_188 PG1_189 PG1_190 PG1_191
+  PG1_192 PG1_193 PG1_194 PG1_195 PG1_196 PG1_197 PG1_198 PG1_199 PG1_200
+  PG1_201 PG1_202 PG1_203 PG1_204 PG1_205 PG1_206 PG1_207 PG1_208 PG1_209
+  PG1_210 PG1_211 PG1_212 PG1_213 PG1_214 PG1_215 PG1_216 PG1_217 PG1_218
+  PG1_219 PG1_220 PG1_221 PG1_222 PG1_223 PG1_224 PG1_225 PG1_226 PG1_227
+  PG1_228 PG1_229 PG1_230 PG1_231 PG1_232 PG1_233 PG1_234 PG1_235 PG1_236
+  PG1_237 PG1_238 PG1_239 PG1_240 PG1_241 PG1_242 PG1_243 PG1_244 PG1_245
+  PG1_246 PG1_247 PG1_248 PG1_249 PG1_250 PG1_251 PG1_252 PG1_253 PG1_254
+  PG1_255 PG2_0 PG2_1 PG2_2 PG2_3 PG2_4 PG2_5 PG2_6 PG2_7 PG2_8 PG2_9 PG2_10
+  PG2_11 PG2_12 PG2_13 PG2_14 PG2_15 PG2_16 PG2_17 PG2_18 PG2_19 PG2_20
+  PG2_21 PG2_22 PG2_23 PG2_24 PG2_25 PG2_26 PG2_27 PG2_28 PG2_29 PG2_30
+  PG2_31 PG2_32 PG2_33 PG2_34 PG2_35 PG2_36 PG2_37 PG2_38 PG2_39 PG2_40
+  PG2_41 PG2_42 PG2_43 PG2_44 PG2_45 PG2_46 PG2_47 PG2_48 PG2_49 PG2_50
+  PG2_51 PG2_52 PG2_53 PG2_54 PG2_55 PG2_56 PG2_57 PG2_58 PG2_59 PG2_60
+  PG2_61 PG2_62 PG2_63 PG2_64 PG2_65 PG2_66 PG2_67 PG2_68 PG2_69 PG2_70
+  PG2_71 PG2_72 PG2_73 PG2_74 PG2_75 PG2_76 PG2_77 PG2_78 PG2_79 PG2_80
+  PG2_81 PG2_82 PG2_83 PG2_84 PG2_85 PG2_86 PG2_87 PG2_88 PG2_89 PG2_90
+  PG2_91 PG2_92 PG2_93 PG2_94 PG2_95 PG2_96 PG2_97 PG2_98 PG2_99 PG2_100
+  PG2_101 PG2_102 PG2_103 PG2_104 PG2_105 PG2_106 PG2_107 PG2_108 PG2_109
+  PG2_110 PG2_111 PG2_112 PG2_113 PG2_114 PG2_115 PG2_116 PG2_117 PG2_118
+  PG2_119 PG2_120 PG2_121 PG2_122 PG2_123 PG2_124 PG2_125 PG2_126 PG2_127
+  PG2_128 PG2_129 PG2_130 PG2_131 PG2_132 PG2_133 PG2_134 PG2_135 PG2_136
+  PG2_137 PG2_138 PG2_139 PG2_140 PG2_141 PG2_142 PG2_143 PG2_144 PG2_145
+  PG2_146 PG2_147 PG2_148 PG2_149 PG2_150 PG2_151 PG2_152 PG2_153 PG2_154
+  PG2_155 PG2_156 PG2_157 PG2_158 PG2_159 PG2_160 PG2_161 PG2_162 PG2_163
+  PG2_164 PG2_165 PG2_166 PG2_167 PG2_168 PG2_169 PG2_170 PG2_171 PG2_172
+  PG2_173 PG2_174 PG2_175 PG2_176 PG2_177 PG2_178 PG2_179 PG2_180 PG2_181
+  PG2_182 PG2_183 PG2_184 PG2_185 PG2_186 PG2_187 PG2_188 PG2_189 PG2_190
+  PG2_191 PG2_192 PG2_193 PG2_194 PG2_195 PG2_196 PG2_197 PG2_198 PG2_199
+  PG2_200 PG2_201 PG2_202 PG2_203 PG2_204 PG2_205 PG2_206 PG2_207 PG2_208
+  PG2_209 PG2_210 PG2_211 PG2_212 PG2_213 PG2_214 PG2_215 PG2_216 PG2_217
+  PG2_218 PG2_219 PG2_220 PG2_221 PG2_222 PG2_223 PG2_224 PG2_225 PG2_226
+  PG2_227 PG2_228 PG2_229 PG2_230 PG2_231 PG2_232 PG2_233 PG2_234 PG2_235
+  PG2_236 PG2_237 PG2_238 PG2_239 PG2_240 PG2_241 PG2_242 PG2_243 PG2_244
+  PG2_245 PG2_246 PG2_247 PG2_248 PG2_249 PG2_250 PG2_251 PG2_252 PG2_253
+  PG2_254 PG2_255 RBTP_0 RBTP_1 RBTP_2 RBTP_3 RDTN_0 RDTN_1 RETL_0 RETL_1
+  RETR_0 RETR_1 RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0 RRA1_1 RRA1__0 RRA1__1
+  RREN_0 RREN_1 TIEHI TIELO XP0_0 XP0_1 XP1_0 XP1_1 XP2_0 XP2_1 XP3_0 XP3_1
+  XP4_0 XP4_1 XP5_0 XP5_1 XP6_0 XP6_1 XP7_0 XP7_1 XP8_0 XP8_1 XP9_0 XP9_1
+  XP10_0 XP10_1 XP11_0 XP11_1 XP12_0 XP12_1 XP13_0 XP13_1 VDDPE VDDCE VSSE
** pe_spad_1024x16_dpBANK_ARRAY_0: 134144 flat devices **
XI0_0 BLA_127 BLA_126 BLA_125 BLA_124 BLA_123 BLA_122 BLA_121 BLA_120 BLA_119
+  BLA_118 BLA_117 BLA_116 BLA_115 BLA_114 BLA_113 BLA_112 BLA_111 BLA_110
+  BLA_109 BLA_108 BLA_107 BLA_106 BLA_105 BLA_104 BLA_103 BLA_102 BLA_101
+  BLA_100 BLA_99 BLA_98 BLA_97 BLA_96 BLA_95 BLA_94 BLA_93 BLA_92 BLA_91
+  BLA_90 BLA_89 BLA_88 BLA_87 BLA_86 BLA_85 BLA_84 BLA_83 BLA_82 BLA_81
+  BLA_80 BLA_79 BLA_78 BLA_77 BLA_76 BLA_75 BLA_74 BLA_73 BLA_72 BLA_71
+  BLA_70 BLA_69 BLA_68 BLA_67 BLA_66 BLA_65 BLA_64 BLA_63 BLA_62 BLA_61
+  BLA_60 BLA_59 BLA_58 BLA_57 BLA_56 BLA_55 BLA_54 BLA_53 BLA_52 BLA_51
+  BLA_50 BLA_49 BLA_48 BLA_47 BLA_46 BLA_45 BLA_44 BLA_43 BLA_42 BLA_41
+  BLA_40 BLA_39 BLA_38 BLA_37 BLA_36 BLA_35 BLA_34 BLA_33 BLA_32 BLA_31
+  BLA_30 BLA_29 BLA_28 BLA_27 BLA_26 BLA_25 BLA_24 BLA_23 BLA_22 BLA_21
+  BLA_20 BLA_19 BLA_18 BLA_17 BLA_16 BLA_15 BLA_14 BLA_13 BLA_12 BLA_11
+  BLA_10 BLA_9 BLA_8 BLA_7 BLA_6 BLA_5 BLA_4 BLA_3 BLA_2 BLA_1 BLA_0 BLA__127
+  BLA__126 BLA__125 BLA__124 BLA__123 BLA__122 BLA__121 BLA__120 BLA__119
+  BLA__118 BLA__117 BLA__116 BLA__115 BLA__114 BLA__113 BLA__112 BLA__111
+  BLA__110 BLA__109 BLA__108 BLA__107 BLA__106 BLA__105 BLA__104 BLA__103
+  BLA__102 BLA__101 BLA__100 BLA__99 BLA__98 BLA__97 BLA__96 BLA__95 BLA__94
+  BLA__93 BLA__92 BLA__91 BLA__90 BLA__89 BLA__88 BLA__87 BLA__86 BLA__85
+  BLA__84 BLA__83 BLA__82 BLA__81 BLA__80 BLA__79 BLA__78 BLA__77 BLA__76
+  BLA__75 BLA__74 BLA__73 BLA__72 BLA__71 BLA__70 BLA__69 BLA__68 BLA__67
+  BLA__66 BLA__65 BLA__64 BLA__63 BLA__62 BLA__61 BLA__60 BLA__59 BLA__58
+  BLA__57 BLA__56 BLA__55 BLA__54 BLA__53 BLA__52 BLA__51 BLA__50 BLA__49
+  BLA__48 BLA__47 BLA__46 BLA__45 BLA__44 BLA__43 BLA__42 BLA__41 BLA__40
+  BLA__39 BLA__38 BLA__37 BLA__36 BLA__35 BLA__34 BLA__33 BLA__32 BLA__31
+  BLA__30 BLA__29 BLA__28 BLA__27 BLA__26 BLA__25 BLA__24 BLA__23 BLA__22
+  BLA__21 BLA__20 BLA__19 BLA__18 BLA__17 BLA__16 BLA__15 BLA__14 BLA__13
+  BLA__12 BLA__11 BLA__10 BLA__9 BLA__8 BLA__7 BLA__6 BLA__5 BLA__4 BLA__3
+  BLA__2 BLA__1 BLA__0 BLB_127 BLB_126 BLB_125 BLB_124 BLB_123 BLB_122
+  BLB_121 BLB_120 BLB_119 BLB_118 BLB_117 BLB_116 BLB_115 BLB_114 BLB_113
+  BLB_112 BLB_111 BLB_110 BLB_109 BLB_108 BLB_107 BLB_106 BLB_105 BLB_104
+  BLB_103 BLB_102 BLB_101 BLB_100 BLB_99 BLB_98 BLB_97 BLB_96 BLB_95 BLB_94
+  BLB_93 BLB_92 BLB_91 BLB_90 BLB_89 BLB_88 BLB_87 BLB_86 BLB_85 BLB_84
+  BLB_83 BLB_82 BLB_81 BLB_80 BLB_79 BLB_78 BLB_77 BLB_76 BLB_75 BLB_74
+  BLB_73 BLB_72 BLB_71 BLB_70 BLB_69 BLB_68 BLB_67 BLB_66 BLB_65 BLB_64
+  BLB_63 BLB_62 BLB_61 BLB_60 BLB_59 BLB_58 BLB_57 BLB_56 BLB_55 BLB_54
+  BLB_53 BLB_52 BLB_51 BLB_50 BLB_49 BLB_48 BLB_47 BLB_46 BLB_45 BLB_44
+  BLB_43 BLB_42 BLB_41 BLB_40 BLB_39 BLB_38 BLB_37 BLB_36 BLB_35 BLB_34
+  BLB_33 BLB_32 BLB_31 BLB_30 BLB_29 BLB_28 BLB_27 BLB_26 BLB_25 BLB_24
+  BLB_23 BLB_22 BLB_21 BLB_20 BLB_19 BLB_18 BLB_17 BLB_16 BLB_15 BLB_14
+  BLB_13 BLB_12 BLB_11 BLB_10 BLB_9 BLB_8 BLB_7 BLB_6 BLB_5 BLB_4 BLB_3 BLB_2
+  BLB_1 BLB_0 BLB__127 BLB__126 BLB__125 BLB__124 BLB__123 BLB__122 BLB__121
+  BLB__120 BLB__119 BLB__118 BLB__117 BLB__116 BLB__115 BLB__114 BLB__113
+  BLB__112 BLB__111 BLB__110 BLB__109 BLB__108 BLB__107 BLB__106 BLB__105
+  BLB__104 BLB__103 BLB__102 BLB__101 BLB__100 BLB__99 BLB__98 BLB__97
+  BLB__96 BLB__95 BLB__94 BLB__93 BLB__92 BLB__91 BLB__90 BLB__89 BLB__88
+  BLB__87 BLB__86 BLB__85 BLB__84 BLB__83 BLB__82 BLB__81 BLB__80 BLB__79
+  BLB__78 BLB__77 BLB__76 BLB__75 BLB__74 BLB__73 BLB__72 BLB__71 BLB__70
+  BLB__69 BLB__68 BLB__67 BLB__66 BLB__65 BLB__64 BLB__63 BLB__62 BLB__61
+  BLB__60 BLB__59 BLB__58 BLB__57 BLB__56 BLB__55 BLB__54 BLB__53 BLB__52
+  BLB__51 BLB__50 BLB__49 BLB__48 BLB__47 BLB__46 BLB__45 BLB__44 BLB__43
+  BLB__42 BLB__41 BLB__40 BLB__39 BLB__38 BLB__37 BLB__36 BLB__35 BLB__34
+  BLB__33 BLB__32 BLB__31 BLB__30 BLB__29 BLB__28 BLB__27 BLB__26 BLB__25
+  BLB__24 BLB__23 BLB__22 BLB__21 BLB__20 BLB__19 BLB__18 BLB__17 BLB__16
+  BLB__15 BLB__14 BLB__13 BLB__12 BLB__11 BLB__10 BLB__9 BLB__8 BLB__7 BLB__6
+  BLB__5 BLB__4 BLB__3 BLB__2 BLB__1 BLB__0 GDL_127 GDL_126 GDL_125 GDL_124
+  GDL_123 GDL_122 GDL_121 GDL_120 GDL_119 GDL_118 GDL_117 GDL_116 GDL_115
+  GDL_114 GDL_113 GDL_112 GDL_111 GDL_110 GDL_109 GDL_108 GDL_107 GDL_106
+  GDL_105 GDL_104 GDL_103 GDL_102 GDL_101 GDL_100 GDL_99 GDL_98 GDL_97 GDL_96
+  GDL_95 GDL_94 GDL_93 GDL_92 GDL_91 GDL_90 GDL_89 GDL_88 GDL_87 GDL_86
+  GDL_85 GDL_84 GDL_83 GDL_82 GDL_81 GDL_80 GDL_79 GDL_78 GDL_77 GDL_76
+  GDL_75 GDL_74 GDL_73 GDL_72 GDL_71 GDL_70 GDL_69 GDL_68 GDL_67 GDL_66
+  GDL_65 GDL_64 GDL_63 GDL_62 GDL_61 GDL_60 GDL_59 GDL_58 GDL_57 GDL_56
+  GDL_55 GDL_54 GDL_53 GDL_52 GDL_51 GDL_50 GDL_49 GDL_48 GDL_47 GDL_46
+  GDL_45 GDL_44 GDL_43 GDL_42 GDL_41 GDL_40 GDL_39 GDL_38 GDL_37 GDL_36
+  GDL_35 GDL_34 GDL_33 GDL_32 GDL_31 GDL_30 GDL_29 GDL_28 GDL_27 GDL_26
+  GDL_25 GDL_24 GDL_23 GDL_22 GDL_21 GDL_20 GDL_19 GDL_18 GDL_17 GDL_16
+  GDL_15 GDL_14 GDL_13 GDL_12 GDL_11 GDL_10 GDL_9 GDL_8 GDL_7 GDL_6 GDL_5
+  GDL_4 GDL_3 GDL_2 GDL_1 GDL_0 MBL_0 PG1_127 PG1_126 PG1_125 PG1_124 PG1_123
+  PG1_122 PG1_121 PG1_120 PG1_119 PG1_118 PG1_117 PG1_116 PG1_115 PG1_114
+  PG1_113 PG1_112 PG1_111 PG1_110 PG1_109 PG1_108 PG1_107 PG1_106 PG1_105
+  PG1_104 PG1_103 PG1_102 PG1_101 PG1_100 PG1_99 PG1_98 PG1_97 PG1_96 PG1_95
+  PG1_94 PG1_93 PG1_92 PG1_91 PG1_90 PG1_89 PG1_88 PG1_87 PG1_86 PG1_85
+  PG1_84 PG1_83 PG1_82 PG1_81 PG1_80 PG1_79 PG1_78 PG1_77 PG1_76 PG1_75
+  PG1_74 PG1_73 PG1_72 PG1_71 PG1_70 PG1_69 PG1_68 PG1_67 PG1_66 PG1_65
+  PG1_64 PG1_63 PG1_62 PG1_61 PG1_60 PG1_59 PG1_58 PG1_57 PG1_56 PG1_55
+  PG1_54 PG1_53 PG1_52 PG1_51 PG1_50 PG1_49 PG1_48 PG1_47 PG1_46 PG1_45
+  PG1_44 PG1_43 PG1_42 PG1_41 PG1_40 PG1_39 PG1_38 PG1_37 PG1_36 PG1_35
+  PG1_34 PG1_33 PG1_32 PG1_31 PG1_30 PG1_29 PG1_28 PG1_27 PG1_26 PG1_25
+  PG1_24 PG1_23 PG1_22 PG1_21 PG1_20 PG1_19 PG1_18 PG1_17 PG1_16 PG1_15
+  PG1_14 PG1_13 PG1_12 PG1_11 PG1_10 PG1_9 PG1_8 PG1_7 PG1_6 PG1_5 PG1_4
+  PG1_3 PG1_2 PG1_1 PG1_0 PG2_127 PG2_126 PG2_125 PG2_124 PG2_123 PG2_122
+  PG2_121 PG2_120 PG2_119 PG2_118 PG2_117 PG2_116 PG2_115 PG2_114 PG2_113
+  PG2_112 PG2_111 PG2_110 PG2_109 PG2_108 PG2_107 PG2_106 PG2_105 PG2_104
+  PG2_103 PG2_102 PG2_101 PG2_100 PG2_99 PG2_98 PG2_97 PG2_96 PG2_95 PG2_94
+  PG2_93 PG2_92 PG2_91 PG2_90 PG2_89 PG2_88 PG2_87 PG2_86 PG2_85 PG2_84
+  PG2_83 PG2_82 PG2_81 PG2_80 PG2_79 PG2_78 PG2_77 PG2_76 PG2_75 PG2_74
+  PG2_73 PG2_72 PG2_71 PG2_70 PG2_69 PG2_68 PG2_67 PG2_66 PG2_65 PG2_64
+  PG2_63 PG2_62 PG2_61 PG2_60 PG2_59 PG2_58 PG2_57 PG2_56 PG2_55 PG2_54
+  PG2_53 PG2_52 PG2_51 PG2_50 PG2_49 PG2_48 PG2_47 PG2_46 PG2_45 PG2_44
+  PG2_43 PG2_42 PG2_41 PG2_40 PG2_39 PG2_38 PG2_37 PG2_36 PG2_35 PG2_34
+  PG2_33 PG2_32 PG2_31 PG2_30 PG2_29 PG2_28 PG2_27 PG2_26 PG2_25 PG2_24
+  PG2_23 PG2_22 PG2_21 PG2_20 PG2_19 PG2_18 PG2_17 PG2_16 PG2_15 PG2_14
+  PG2_13 PG2_12 PG2_11 PG2_10 PG2_9 PG2_8 PG2_7 PG2_6 PG2_5 PG2_4 PG2_3 PG2_2
+  PG2_1 PG2_0 TIEHI TIEHI TIELO WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCORE_ARRAY_L_B
XI1_0 AX0TRACK_0 AX1TRACK_0 AX2TRACK_0 AX3TRACK_0 AX4TRACK_0 AX5TRACK_0
+  AY0TRACK_0 AY1TRACK_0 BS0N_0 BS1N_0 BS2N_0 BTP_0 GTP_0 GTPD_0 GTPDE_0
+  LGWE_0 MGDLE_0 MGDLS_0 MGTPE_0 MGTPS_0 RBTP_0 RBTP_2 RDTN_0 RETL_0 RETR_0
+  RRA0_0 RRA0__0 RRA1_0 RRA1__0 RREN_0 TIEHI TIELO WLA_1 WLA_2 WLA_5 WLA_6
+  WLA_9 WLA_10 WLA_13 WLA_14 WLA_17 WLA_18 WLA_21 WLA_22 WLA_25 WLA_26 WLA_29
+  WLA_30 WLA_33 WLA_34 WLA_37 WLA_38 WLA_41 WLA_42 WLA_45 WLA_46 WLA_49
+  WLA_50 WLA_53 WLA_54 WLA_57 WLA_58 WLA_61 WLA_62 WLA_0 WLA_3 WLA_4 WLA_7
+  WLA_8 WLA_11 WLA_12 WLA_15 WLA_16 WLA_19 WLA_20 WLA_23 WLA_24 WLA_27 WLA_28
+  WLA_31 WLA_32 WLA_35 WLA_36 WLA_39 WLA_40 WLA_43 WLA_44 WLA_47 WLA_48
+  WLA_51 WLA_52 WLA_55 WLA_56 WLA_59 WLA_60 WLA_63 WLB_1 WLB_2 WLB_5 WLB_6
+  WLB_9 WLB_10 WLB_13 WLB_14 WLB_17 WLB_18 WLB_21 WLB_22 WLB_25 WLB_26 WLB_29
+  WLB_30 WLB_33 WLB_34 WLB_37 WLB_38 WLB_41 WLB_42 WLB_45 WLB_46 WLB_49
+  WLB_50 WLB_53 WLB_54 WLB_57 WLB_58 WLB_61 WLB_62 WLB_0 WLB_3 WLB_4 WLB_7
+  WLB_8 WLB_11 WLB_12 WLB_15 WLB_16 WLB_19 WLB_20 WLB_23 WLB_24 WLB_27 WLB_28
+  WLB_31 WLB_32 WLB_35 WLB_36 WLB_39 WLB_40 WLB_43 WLB_44 WLB_47 WLB_48
+  WLB_51 WLB_52 WLB_55 WLB_56 WLB_59 WLB_60 WLB_63 XP0_0 XP1_0 XP2_0 XP3_0
+  XP4_0 XP5_0 XP6_0 XP7_0 XP8_0 XP9_0 XP10_0 XP11_0 XP12_0 XP13_0 VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpWDSTACK_L_0
XI2_0 AX0TRACK_1 AX1TRACK_1 AX2TRACK_1 AX3TRACK_1 AX4TRACK_1 AX5TRACK_1
+  AY0TRACK_1 AY1TRACK_1 BS0N_1 BS1N_1 BS2N_1 BTP_1 GTP_1 GTPD_1 GTPDE_1
+  LGWE_1 MGDLE_1 MGDLS_1 MGTPE_1 MGTPS_1 RBTP_1 RBTP_3 RDTN_1 RETL_1 RETR_1
+  RRA0_1 RRA0__1 RRA1_1 RRA1__1 RREN_1 TIEHI TIELO WLA_1 WLA_2 WLA_5 WLA_6
+  WLA_9 WLA_10 WLA_13 WLA_14 WLA_17 WLA_18 WLA_21 WLA_22 WLA_25 WLA_26 WLA_29
+  WLA_30 WLA_33 WLA_34 WLA_37 WLA_38 WLA_41 WLA_42 WLA_45 WLA_46 WLA_49
+  WLA_50 WLA_53 WLA_54 WLA_57 WLA_58 WLA_61 WLA_62 WLA_0 WLA_3 WLA_4 WLA_7
+  WLA_8 WLA_11 WLA_12 WLA_15 WLA_16 WLA_19 WLA_20 WLA_23 WLA_24 WLA_27 WLA_28
+  WLA_31 WLA_32 WLA_35 WLA_36 WLA_39 WLA_40 WLA_43 WLA_44 WLA_47 WLA_48
+  WLA_51 WLA_52 WLA_55 WLA_56 WLA_59 WLA_60 WLA_63 WLB_1 WLB_2 WLB_5 WLB_6
+  WLB_9 WLB_10 WLB_13 WLB_14 WLB_17 WLB_18 WLB_21 WLB_22 WLB_25 WLB_26 WLB_29
+  WLB_30 WLB_33 WLB_34 WLB_37 WLB_38 WLB_41 WLB_42 WLB_45 WLB_46 WLB_49
+  WLB_50 WLB_53 WLB_54 WLB_57 WLB_58 WLB_61 WLB_62 WLB_0 WLB_3 WLB_4 WLB_7
+  WLB_8 WLB_11 WLB_12 WLB_15 WLB_16 WLB_19 WLB_20 WLB_23 WLB_24 WLB_27 WLB_28
+  WLB_31 WLB_32 WLB_35 WLB_36 WLB_39 WLB_40 WLB_43 WLB_44 WLB_47 WLB_48
+  WLB_51 WLB_52 WLB_55 WLB_56 WLB_59 WLB_60 WLB_63 XP0_1 XP1_1 XP2_1 XP3_1
+  XP4_1 XP5_1 XP6_1 XP7_1 XP8_1 XP9_1 XP10_1 XP11_1 XP12_1 XP13_1 VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpWDSTACK_R_0
XI3_0 BLA_128 BLA_129 BLA_130 BLA_131 BLA_132 BLA_133 BLA_134 BLA_135 BLA_136
+  BLA_137 BLA_138 BLA_139 BLA_140 BLA_141 BLA_142 BLA_143 BLA_144 BLA_145
+  BLA_146 BLA_147 BLA_148 BLA_149 BLA_150 BLA_151 BLA_152 BLA_153 BLA_154
+  BLA_155 BLA_156 BLA_157 BLA_158 BLA_159 BLA_160 BLA_161 BLA_162 BLA_163
+  BLA_164 BLA_165 BLA_166 BLA_167 BLA_168 BLA_169 BLA_170 BLA_171 BLA_172
+  BLA_173 BLA_174 BLA_175 BLA_176 BLA_177 BLA_178 BLA_179 BLA_180 BLA_181
+  BLA_182 BLA_183 BLA_184 BLA_185 BLA_186 BLA_187 BLA_188 BLA_189 BLA_190
+  BLA_191 BLA_192 BLA_193 BLA_194 BLA_195 BLA_196 BLA_197 BLA_198 BLA_199
+  BLA_200 BLA_201 BLA_202 BLA_203 BLA_204 BLA_205 BLA_206 BLA_207 BLA_208
+  BLA_209 BLA_210 BLA_211 BLA_212 BLA_213 BLA_214 BLA_215 BLA_216 BLA_217
+  BLA_218 BLA_219 BLA_220 BLA_221 BLA_222 BLA_223 BLA_224 BLA_225 BLA_226
+  BLA_227 BLA_228 BLA_229 BLA_230 BLA_231 BLA_232 BLA_233 BLA_234 BLA_235
+  BLA_236 BLA_237 BLA_238 BLA_239 BLA_240 BLA_241 BLA_242 BLA_243 BLA_244
+  BLA_245 BLA_246 BLA_247 BLA_248 BLA_249 BLA_250 BLA_251 BLA_252 BLA_253
+  BLA_254 BLA_255 BLA__128 BLA__129 BLA__130 BLA__131 BLA__132 BLA__133
+  BLA__134 BLA__135 BLA__136 BLA__137 BLA__138 BLA__139 BLA__140 BLA__141
+  BLA__142 BLA__143 BLA__144 BLA__145 BLA__146 BLA__147 BLA__148 BLA__149
+  BLA__150 BLA__151 BLA__152 BLA__153 BLA__154 BLA__155 BLA__156 BLA__157
+  BLA__158 BLA__159 BLA__160 BLA__161 BLA__162 BLA__163 BLA__164 BLA__165
+  BLA__166 BLA__167 BLA__168 BLA__169 BLA__170 BLA__171 BLA__172 BLA__173
+  BLA__174 BLA__175 BLA__176 BLA__177 BLA__178 BLA__179 BLA__180 BLA__181
+  BLA__182 BLA__183 BLA__184 BLA__185 BLA__186 BLA__187 BLA__188 BLA__189
+  BLA__190 BLA__191 BLA__192 BLA__193 BLA__194 BLA__195 BLA__196 BLA__197
+  BLA__198 BLA__199 BLA__200 BLA__201 BLA__202 BLA__203 BLA__204 BLA__205
+  BLA__206 BLA__207 BLA__208 BLA__209 BLA__210 BLA__211 BLA__212 BLA__213
+  BLA__214 BLA__215 BLA__216 BLA__217 BLA__218 BLA__219 BLA__220 BLA__221
+  BLA__222 BLA__223 BLA__224 BLA__225 BLA__226 BLA__227 BLA__228 BLA__229
+  BLA__230 BLA__231 BLA__232 BLA__233 BLA__234 BLA__235 BLA__236 BLA__237
+  BLA__238 BLA__239 BLA__240 BLA__241 BLA__242 BLA__243 BLA__244 BLA__245
+  BLA__246 BLA__247 BLA__248 BLA__249 BLA__250 BLA__251 BLA__252 BLA__253
+  BLA__254 BLA__255 BLB_128 BLB_129 BLB_130 BLB_131 BLB_132 BLB_133 BLB_134
+  BLB_135 BLB_136 BLB_137 BLB_138 BLB_139 BLB_140 BLB_141 BLB_142 BLB_143
+  BLB_144 BLB_145 BLB_146 BLB_147 BLB_148 BLB_149 BLB_150 BLB_151 BLB_152
+  BLB_153 BLB_154 BLB_155 BLB_156 BLB_157 BLB_158 BLB_159 BLB_160 BLB_161
+  BLB_162 BLB_163 BLB_164 BLB_165 BLB_166 BLB_167 BLB_168 BLB_169 BLB_170
+  BLB_171 BLB_172 BLB_173 BLB_174 BLB_175 BLB_176 BLB_177 BLB_178 BLB_179
+  BLB_180 BLB_181 BLB_182 BLB_183 BLB_184 BLB_185 BLB_186 BLB_187 BLB_188
+  BLB_189 BLB_190 BLB_191 BLB_192 BLB_193 BLB_194 BLB_195 BLB_196 BLB_197
+  BLB_198 BLB_199 BLB_200 BLB_201 BLB_202 BLB_203 BLB_204 BLB_205 BLB_206
+  BLB_207 BLB_208 BLB_209 BLB_210 BLB_211 BLB_212 BLB_213 BLB_214 BLB_215
+  BLB_216 BLB_217 BLB_218 BLB_219 BLB_220 BLB_221 BLB_222 BLB_223 BLB_224
+  BLB_225 BLB_226 BLB_227 BLB_228 BLB_229 BLB_230 BLB_231 BLB_232 BLB_233
+  BLB_234 BLB_235 BLB_236 BLB_237 BLB_238 BLB_239 BLB_240 BLB_241 BLB_242
+  BLB_243 BLB_244 BLB_245 BLB_246 BLB_247 BLB_248 BLB_249 BLB_250 BLB_251
+  BLB_252 BLB_253 BLB_254 BLB_255 BLB__128 BLB__129 BLB__130 BLB__131
+  BLB__132 BLB__133 BLB__134 BLB__135 BLB__136 BLB__137 BLB__138 BLB__139
+  BLB__140 BLB__141 BLB__142 BLB__143 BLB__144 BLB__145 BLB__146 BLB__147
+  BLB__148 BLB__149 BLB__150 BLB__151 BLB__152 BLB__153 BLB__154 BLB__155
+  BLB__156 BLB__157 BLB__158 BLB__159 BLB__160 BLB__161 BLB__162 BLB__163
+  BLB__164 BLB__165 BLB__166 BLB__167 BLB__168 BLB__169 BLB__170 BLB__171
+  BLB__172 BLB__173 BLB__174 BLB__175 BLB__176 BLB__177 BLB__178 BLB__179
+  BLB__180 BLB__181 BLB__182 BLB__183 BLB__184 BLB__185 BLB__186 BLB__187
+  BLB__188 BLB__189 BLB__190 BLB__191 BLB__192 BLB__193 BLB__194 BLB__195
+  BLB__196 BLB__197 BLB__198 BLB__199 BLB__200 BLB__201 BLB__202 BLB__203
+  BLB__204 BLB__205 BLB__206 BLB__207 BLB__208 BLB__209 BLB__210 BLB__211
+  BLB__212 BLB__213 BLB__214 BLB__215 BLB__216 BLB__217 BLB__218 BLB__219
+  BLB__220 BLB__221 BLB__222 BLB__223 BLB__224 BLB__225 BLB__226 BLB__227
+  BLB__228 BLB__229 BLB__230 BLB__231 BLB__232 BLB__233 BLB__234 BLB__235
+  BLB__236 BLB__237 BLB__238 BLB__239 BLB__240 BLB__241 BLB__242 BLB__243
+  BLB__244 BLB__245 BLB__246 BLB__247 BLB__248 BLB__249 BLB__250 BLB__251
+  BLB__252 BLB__253 BLB__254 BLB__255 GDL_128 GDL_129 GDL_130 GDL_131 GDL_132
+  GDL_133 GDL_134 GDL_135 GDL_136 GDL_137 GDL_138 GDL_139 GDL_140 GDL_141
+  GDL_142 GDL_143 GDL_144 GDL_145 GDL_146 GDL_147 GDL_148 GDL_149 GDL_150
+  GDL_151 GDL_152 GDL_153 GDL_154 GDL_155 GDL_156 GDL_157 GDL_158 GDL_159
+  GDL_160 GDL_161 GDL_162 GDL_163 GDL_164 GDL_165 GDL_166 GDL_167 GDL_168
+  GDL_169 GDL_170 GDL_171 GDL_172 GDL_173 GDL_174 GDL_175 GDL_176 GDL_177
+  GDL_178 GDL_179 GDL_180 GDL_181 GDL_182 GDL_183 GDL_184 GDL_185 GDL_186
+  GDL_187 GDL_188 GDL_189 GDL_190 GDL_191 GDL_192 GDL_193 GDL_194 GDL_195
+  GDL_196 GDL_197 GDL_198 GDL_199 GDL_200 GDL_201 GDL_202 GDL_203 GDL_204
+  GDL_205 GDL_206 GDL_207 GDL_208 GDL_209 GDL_210 GDL_211 GDL_212 GDL_213
+  GDL_214 GDL_215 GDL_216 GDL_217 GDL_218 GDL_219 GDL_220 GDL_221 GDL_222
+  GDL_223 GDL_224 GDL_225 GDL_226 GDL_227 GDL_228 GDL_229 GDL_230 GDL_231
+  GDL_232 GDL_233 GDL_234 GDL_235 GDL_236 GDL_237 GDL_238 GDL_239 GDL_240
+  GDL_241 GDL_242 GDL_243 GDL_244 GDL_245 GDL_246 GDL_247 GDL_248 GDL_249
+  GDL_250 GDL_251 GDL_252 GDL_253 GDL_254 GDL_255 MBL_1 PG1_128 PG1_129
+  PG1_130 PG1_131 PG1_132 PG1_133 PG1_134 PG1_135 PG1_136 PG1_137 PG1_138
+  PG1_139 PG1_140 PG1_141 PG1_142 PG1_143 PG1_144 PG1_145 PG1_146 PG1_147
+  PG1_148 PG1_149 PG1_150 PG1_151 PG1_152 PG1_153 PG1_154 PG1_155 PG1_156
+  PG1_157 PG1_158 PG1_159 PG1_160 PG1_161 PG1_162 PG1_163 PG1_164 PG1_165
+  PG1_166 PG1_167 PG1_168 PG1_169 PG1_170 PG1_171 PG1_172 PG1_173 PG1_174
+  PG1_175 PG1_176 PG1_177 PG1_178 PG1_179 PG1_180 PG1_181 PG1_182 PG1_183
+  PG1_184 PG1_185 PG1_186 PG1_187 PG1_188 PG1_189 PG1_190 PG1_191 PG1_192
+  PG1_193 PG1_194 PG1_195 PG1_196 PG1_197 PG1_198 PG1_199 PG1_200 PG1_201
+  PG1_202 PG1_203 PG1_204 PG1_205 PG1_206 PG1_207 PG1_208 PG1_209 PG1_210
+  PG1_211 PG1_212 PG1_213 PG1_214 PG1_215 PG1_216 PG1_217 PG1_218 PG1_219
+  PG1_220 PG1_221 PG1_222 PG1_223 PG1_224 PG1_225 PG1_226 PG1_227 PG1_228
+  PG1_229 PG1_230 PG1_231 PG1_232 PG1_233 PG1_234 PG1_235 PG1_236 PG1_237
+  PG1_238 PG1_239 PG1_240 PG1_241 PG1_242 PG1_243 PG1_244 PG1_245 PG1_246
+  PG1_247 PG1_248 PG1_249 PG1_250 PG1_251 PG1_252 PG1_253 PG1_254 PG1_255
+  PG2_128 PG2_129 PG2_130 PG2_131 PG2_132 PG2_133 PG2_134 PG2_135 PG2_136
+  PG2_137 PG2_138 PG2_139 PG2_140 PG2_141 PG2_142 PG2_143 PG2_144 PG2_145
+  PG2_146 PG2_147 PG2_148 PG2_149 PG2_150 PG2_151 PG2_152 PG2_153 PG2_154
+  PG2_155 PG2_156 PG2_157 PG2_158 PG2_159 PG2_160 PG2_161 PG2_162 PG2_163
+  PG2_164 PG2_165 PG2_166 PG2_167 PG2_168 PG2_169 PG2_170 PG2_171 PG2_172
+  PG2_173 PG2_174 PG2_175 PG2_176 PG2_177 PG2_178 PG2_179 PG2_180 PG2_181
+  PG2_182 PG2_183 PG2_184 PG2_185 PG2_186 PG2_187 PG2_188 PG2_189 PG2_190
+  PG2_191 PG2_192 PG2_193 PG2_194 PG2_195 PG2_196 PG2_197 PG2_198 PG2_199
+  PG2_200 PG2_201 PG2_202 PG2_203 PG2_204 PG2_205 PG2_206 PG2_207 PG2_208
+  PG2_209 PG2_210 PG2_211 PG2_212 PG2_213 PG2_214 PG2_215 PG2_216 PG2_217
+  PG2_218 PG2_219 PG2_220 PG2_221 PG2_222 PG2_223 PG2_224 PG2_225 PG2_226
+  PG2_227 PG2_228 PG2_229 PG2_230 PG2_231 PG2_232 PG2_233 PG2_234 PG2_235
+  PG2_236 PG2_237 PG2_238 PG2_239 PG2_240 PG2_241 PG2_242 PG2_243 PG2_244
+  PG2_245 PG2_246 PG2_247 PG2_248 PG2_249 PG2_250 PG2_251 PG2_252 PG2_253
+  PG2_254 PG2_255 TIEHI TIEHI TIELO WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLA_31 WLA_32 WLA_33 WLA_34 WLA_35 WLA_36 WLA_37
+  WLA_38 WLA_39 WLA_40 WLA_41 WLA_42 WLA_43 WLA_44 WLA_45 WLA_46 WLA_47
+  WLA_48 WLA_49 WLA_50 WLA_51 WLA_52 WLA_53 WLA_54 WLA_55 WLA_56 WLA_57
+  WLA_58 WLA_59 WLA_60 WLA_61 WLA_62 WLA_63 WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 WLB_31 WLB_32 WLB_33 WLB_34 WLB_35
+  WLB_36 WLB_37 WLB_38 WLB_39 WLB_40 WLB_41 WLB_42 WLB_43 WLB_44 WLB_45
+  WLB_46 WLB_47 WLB_48 WLB_49 WLB_50 WLB_51 WLB_52 WLB_53 WLB_54 WLB_55
+  WLB_56 WLB_57 WLB_58 WLB_59 WLB_60 WLB_61 WLB_62 WLB_63 VDDPE VDDCE VSSE
+  pe_spad_1024x16_dpCORE_ARRAY_R_B
.ENDS pe_spad_1024x16_dpBANK_ARRAY_0
****
.SUBCKT pe_spad_1024x16_dpFULL_1BANK AX0TRACK_0 AX0TRACK_1 AX1TRACK_0
+  AX1TRACK_1 AX2TRACK_0 AX2TRACK_1 AX3TRACK_0 AX3TRACK_1 AX4TRACK_0
+  AX4TRACK_1 AX5TRACK_0 AX5TRACK_1 AY0TRACK_0 AY0TRACK_1 AY1TRACK_0
+  AY1TRACK_1 BS0N_0 BS0N_1 BS1N_0 BS1N_1 BS2N_0 BS2N_1 GDL_0 GDL_1 GDL_2
+  GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13
+  GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23
+  GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33
+  GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43
+  GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53
+  GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63
+  GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73
+  GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83
+  GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93
+  GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103
+  GDL_104 GDL_105 GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112
+  GDL_113 GDL_114 GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121
+  GDL_122 GDL_123 GDL_124 GDL_125 GDL_126 GDL_127 GDL__0 GDL__1 GDL__2 GDL__3
+  GDL__4 GDL__5 GDL__6 GDL__7 GDL__8 GDL__9 GDL__10 GDL__11 GDL__12 GDL__13
+  GDL__14 GDL__15 GDL__16 GDL__17 GDL__18 GDL__19 GDL__20 GDL__21 GDL__22
+  GDL__23 GDL__24 GDL__25 GDL__26 GDL__27 GDL__28 GDL__29 GDL__30 GDL__31
+  GDL__32 GDL__33 GDL__34 GDL__35 GDL__36 GDL__37 GDL__38 GDL__39 GDL__40
+  GDL__41 GDL__42 GDL__43 GDL__44 GDL__45 GDL__46 GDL__47 GDL__48 GDL__49
+  GDL__50 GDL__51 GDL__52 GDL__53 GDL__54 GDL__55 GDL__56 GDL__57 GDL__58
+  GDL__59 GDL__60 GDL__61 GDL__62 GDL__63 GDL__64 GDL__65 GDL__66 GDL__67
+  GDL__68 GDL__69 GDL__70 GDL__71 GDL__72 GDL__73 GDL__74 GDL__75 GDL__76
+  GDL__77 GDL__78 GDL__79 GDL__80 GDL__81 GDL__82 GDL__83 GDL__84 GDL__85
+  GDL__86 GDL__87 GDL__88 GDL__89 GDL__90 GDL__91 GDL__92 GDL__93 GDL__94
+  GDL__95 GDL__96 GDL__97 GDL__98 GDL__99 GDL__100 GDL__101 GDL__102 GDL__103
+  GDL__104 GDL__105 GDL__106 GDL__107 GDL__108 GDL__109 GDL__110 GDL__111
+  GDL__112 GDL__113 GDL__114 GDL__115 GDL__116 GDL__117 GDL__118 GDL__119
+  GDL__120 GDL__121 GDL__122 GDL__123 GDL__124 GDL__125 GDL__126 GDL__127
+  GTPD_0 GTPD_1 GTP_0 GTP_1 LGWE_0 LGWE_1 MBL_0 MBL_1 MGDLE_0 MGDLE_1 MGTPS_0
+  MGTPS_1 RDTN_0 RDTN_1 RET_0 RET_1 RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0
+  RRA1_1 RRA1__0 RRA1__1 RREN_0 RREN_1 TIEHI TIELO WBT_0 WBT_1 VDDPE VDDCE
+  VSSE
** pe_spad_1024x16_dpFULL_1BANK: 152124 flat devices **
XI0_0 AX0TRACK_0 AX0TRACK_1 AX1TRACK_0 AX1TRACK_1 AX2TRACK_0 AX2TRACK_1
+  AX3TRACK_0 AX3TRACK_1 AX4TRACK_0 AX4TRACK_1 AX5TRACK_0 AX5TRACK_1
+  AY0TRACK_0 AY0TRACK_1 AY1TRACK_0 AY1TRACK_1 BL0_A_0 BL0_A_1 BL0_A_2 BL0_A_3
+  BL0_A_4 BL0_A_5 BL0_A_6 BL0_A_7 BL0_A_8 BL0_A_9 BL0_A_10 BL0_A_11 BL0_A_12
+  BL0_A_13 BL0_A_14 BL0_A_15 BL0_A_16 BL0_A_17 BL0_A_18 BL0_A_19 BL0_A_20
+  BL0_A_21 BL0_A_22 BL0_A_23 BL0_A_24 BL0_A_25 BL0_A_26 BL0_A_27 BL0_A_28
+  BL0_A_29 BL0_A_30 BL0_A_31 BL0_A_32 BL0_A_33 BL0_A_34 BL0_A_35 BL0_A_36
+  BL0_A_37 BL0_A_38 BL0_A_39 BL0_A_40 BL0_A_41 BL0_A_42 BL0_A_43 BL0_A_44
+  BL0_A_45 BL0_A_46 BL0_A_47 BL0_A_48 BL0_A_49 BL0_A_50 BL0_A_51 BL0_A_52
+  BL0_A_53 BL0_A_54 BL0_A_55 BL0_A_56 BL0_A_57 BL0_A_58 BL0_A_59 BL0_A_60
+  BL0_A_61 BL0_A_62 BL0_A_63 BL0_B_0 BL0_B_1 BL0_B_2 BL0_B_3 BL0_B_4 BL0_B_5
+  BL0_B_6 BL0_B_7 BL0_B_8 BL0_B_9 BL0_B_10 BL0_B_11 BL0_B_12 BL0_B_13
+  BL0_B_14 BL0_B_15 BL0_B_16 BL0_B_17 BL0_B_18 BL0_B_19 BL0_B_20 BL0_B_21
+  BL0_B_22 BL0_B_23 BL0_B_24 BL0_B_25 BL0_B_26 BL0_B_27 BL0_B_28 BL0_B_29
+  BL0_B_30 BL0_B_31 BL0_B_32 BL0_B_33 BL0_B_34 BL0_B_35 BL0_B_36 BL0_B_37
+  BL0_B_38 BL0_B_39 BL0_B_40 BL0_B_41 BL0_B_42 BL0_B_43 BL0_B_44 BL0_B_45
+  BL0_B_46 BL0_B_47 BL0_B_48 BL0_B_49 BL0_B_50 BL0_B_51 BL0_B_52 BL0_B_53
+  BL0_B_54 BL0_B_55 BL0_B_56 BL0_B_57 BL0_B_58 BL0_B_59 BL0_B_60 BL0_B_61
+  BL0_B_62 BL0_B_63 BL0__A_0 BL0__A_1 BL0__A_2 BL0__A_3 BL0__A_4 BL0__A_5
+  BL0__A_6 BL0__A_7 BL0__A_8 BL0__A_9 BL0__A_10 BL0__A_11 BL0__A_12 BL0__A_13
+  BL0__A_14 BL0__A_15 BL0__A_16 BL0__A_17 BL0__A_18 BL0__A_19 BL0__A_20
+  BL0__A_21 BL0__A_22 BL0__A_23 BL0__A_24 BL0__A_25 BL0__A_26 BL0__A_27
+  BL0__A_28 BL0__A_29 BL0__A_30 BL0__A_31 BL0__A_32 BL0__A_33 BL0__A_34
+  BL0__A_35 BL0__A_36 BL0__A_37 BL0__A_38 BL0__A_39 BL0__A_40 BL0__A_41
+  BL0__A_42 BL0__A_43 BL0__A_44 BL0__A_45 BL0__A_46 BL0__A_47 BL0__A_48
+  BL0__A_49 BL0__A_50 BL0__A_51 BL0__A_52 BL0__A_53 BL0__A_54 BL0__A_55
+  BL0__A_56 BL0__A_57 BL0__A_58 BL0__A_59 BL0__A_60 BL0__A_61 BL0__A_62
+  BL0__A_63 BL0__B_0 BL0__B_1 BL0__B_2 BL0__B_3 BL0__B_4 BL0__B_5 BL0__B_6
+  BL0__B_7 BL0__B_8 BL0__B_9 BL0__B_10 BL0__B_11 BL0__B_12 BL0__B_13
+  BL0__B_14 BL0__B_15 BL0__B_16 BL0__B_17 BL0__B_18 BL0__B_19 BL0__B_20
+  BL0__B_21 BL0__B_22 BL0__B_23 BL0__B_24 BL0__B_25 BL0__B_26 BL0__B_27
+  BL0__B_28 BL0__B_29 BL0__B_30 BL0__B_31 BL0__B_32 BL0__B_33 BL0__B_34
+  BL0__B_35 BL0__B_36 BL0__B_37 BL0__B_38 BL0__B_39 BL0__B_40 BL0__B_41
+  BL0__B_42 BL0__B_43 BL0__B_44 BL0__B_45 BL0__B_46 BL0__B_47 BL0__B_48
+  BL0__B_49 BL0__B_50 BL0__B_51 BL0__B_52 BL0__B_53 BL0__B_54 BL0__B_55
+  BL0__B_56 BL0__B_57 BL0__B_58 BL0__B_59 BL0__B_60 BL0__B_61 BL0__B_62
+  BL0__B_63 BL1_A_0 BL1_A_1 BL1_A_2 BL1_A_3 BL1_A_4 BL1_A_5 BL1_A_6 BL1_A_7
+  BL1_A_8 BL1_A_9 BL1_A_10 BL1_A_11 BL1_A_12 BL1_A_13 BL1_A_14 BL1_A_15
+  BL1_A_16 BL1_A_17 BL1_A_18 BL1_A_19 BL1_A_20 BL1_A_21 BL1_A_22 BL1_A_23
+  BL1_A_24 BL1_A_25 BL1_A_26 BL1_A_27 BL1_A_28 BL1_A_29 BL1_A_30 BL1_A_31
+  BL1_A_32 BL1_A_33 BL1_A_34 BL1_A_35 BL1_A_36 BL1_A_37 BL1_A_38 BL1_A_39
+  BL1_A_40 BL1_A_41 BL1_A_42 BL1_A_43 BL1_A_44 BL1_A_45 BL1_A_46 BL1_A_47
+  BL1_A_48 BL1_A_49 BL1_A_50 BL1_A_51 BL1_A_52 BL1_A_53 BL1_A_54 BL1_A_55
+  BL1_A_56 BL1_A_57 BL1_A_58 BL1_A_59 BL1_A_60 BL1_A_61 BL1_A_62 BL1_A_63
+  BL1_B_0 BL1_B_1 BL1_B_2 BL1_B_3 BL1_B_4 BL1_B_5 BL1_B_6 BL1_B_7 BL1_B_8
+  BL1_B_9 BL1_B_10 BL1_B_11 BL1_B_12 BL1_B_13 BL1_B_14 BL1_B_15 BL1_B_16
+  BL1_B_17 BL1_B_18 BL1_B_19 BL1_B_20 BL1_B_21 BL1_B_22 BL1_B_23 BL1_B_24
+  BL1_B_25 BL1_B_26 BL1_B_27 BL1_B_28 BL1_B_29 BL1_B_30 BL1_B_31 BL1_B_32
+  BL1_B_33 BL1_B_34 BL1_B_35 BL1_B_36 BL1_B_37 BL1_B_38 BL1_B_39 BL1_B_40
+  BL1_B_41 BL1_B_42 BL1_B_43 BL1_B_44 BL1_B_45 BL1_B_46 BL1_B_47 BL1_B_48
+  BL1_B_49 BL1_B_50 BL1_B_51 BL1_B_52 BL1_B_53 BL1_B_54 BL1_B_55 BL1_B_56
+  BL1_B_57 BL1_B_58 BL1_B_59 BL1_B_60 BL1_B_61 BL1_B_62 BL1_B_63 BL1__A_0
+  BL1__A_1 BL1__A_2 BL1__A_3 BL1__A_4 BL1__A_5 BL1__A_6 BL1__A_7 BL1__A_8
+  BL1__A_9 BL1__A_10 BL1__A_11 BL1__A_12 BL1__A_13 BL1__A_14 BL1__A_15
+  BL1__A_16 BL1__A_17 BL1__A_18 BL1__A_19 BL1__A_20 BL1__A_21 BL1__A_22
+  BL1__A_23 BL1__A_24 BL1__A_25 BL1__A_26 BL1__A_27 BL1__A_28 BL1__A_29
+  BL1__A_30 BL1__A_31 BL1__A_32 BL1__A_33 BL1__A_34 BL1__A_35 BL1__A_36
+  BL1__A_37 BL1__A_38 BL1__A_39 BL1__A_40 BL1__A_41 BL1__A_42 BL1__A_43
+  BL1__A_44 BL1__A_45 BL1__A_46 BL1__A_47 BL1__A_48 BL1__A_49 BL1__A_50
+  BL1__A_51 BL1__A_52 BL1__A_53 BL1__A_54 BL1__A_55 BL1__A_56 BL1__A_57
+  BL1__A_58 BL1__A_59 BL1__A_60 BL1__A_61 BL1__A_62 BL1__A_63 BL1__B_0
+  BL1__B_1 BL1__B_2 BL1__B_3 BL1__B_4 BL1__B_5 BL1__B_6 BL1__B_7 BL1__B_8
+  BL1__B_9 BL1__B_10 BL1__B_11 BL1__B_12 BL1__B_13 BL1__B_14 BL1__B_15
+  BL1__B_16 BL1__B_17 BL1__B_18 BL1__B_19 BL1__B_20 BL1__B_21 BL1__B_22
+  BL1__B_23 BL1__B_24 BL1__B_25 BL1__B_26 BL1__B_27 BL1__B_28 BL1__B_29
+  BL1__B_30 BL1__B_31 BL1__B_32 BL1__B_33 BL1__B_34 BL1__B_35 BL1__B_36
+  BL1__B_37 BL1__B_38 BL1__B_39 BL1__B_40 BL1__B_41 BL1__B_42 BL1__B_43
+  BL1__B_44 BL1__B_45 BL1__B_46 BL1__B_47 BL1__B_48 BL1__B_49 BL1__B_50
+  BL1__B_51 BL1__B_52 BL1__B_53 BL1__B_54 BL1__B_55 BL1__B_56 BL1__B_57
+  BL1__B_58 BL1__B_59 BL1__B_60 BL1__B_61 BL1__B_62 BL1__B_63 BL2_A_0 BL2_A_1
+  BL2_A_2 BL2_A_3 BL2_A_4 BL2_A_5 BL2_A_6 BL2_A_7 BL2_A_8 BL2_A_9 BL2_A_10
+  BL2_A_11 BL2_A_12 BL2_A_13 BL2_A_14 BL2_A_15 BL2_A_16 BL2_A_17 BL2_A_18
+  BL2_A_19 BL2_A_20 BL2_A_21 BL2_A_22 BL2_A_23 BL2_A_24 BL2_A_25 BL2_A_26
+  BL2_A_27 BL2_A_28 BL2_A_29 BL2_A_30 BL2_A_31 BL2_A_32 BL2_A_33 BL2_A_34
+  BL2_A_35 BL2_A_36 BL2_A_37 BL2_A_38 BL2_A_39 BL2_A_40 BL2_A_41 BL2_A_42
+  BL2_A_43 BL2_A_44 BL2_A_45 BL2_A_46 BL2_A_47 BL2_A_48 BL2_A_49 BL2_A_50
+  BL2_A_51 BL2_A_52 BL2_A_53 BL2_A_54 BL2_A_55 BL2_A_56 BL2_A_57 BL2_A_58
+  BL2_A_59 BL2_A_60 BL2_A_61 BL2_A_62 BL2_A_63 BL2_B_0 BL2_B_1 BL2_B_2
+  BL2_B_3 BL2_B_4 BL2_B_5 BL2_B_6 BL2_B_7 BL2_B_8 BL2_B_9 BL2_B_10 BL2_B_11
+  BL2_B_12 BL2_B_13 BL2_B_14 BL2_B_15 BL2_B_16 BL2_B_17 BL2_B_18 BL2_B_19
+  BL2_B_20 BL2_B_21 BL2_B_22 BL2_B_23 BL2_B_24 BL2_B_25 BL2_B_26 BL2_B_27
+  BL2_B_28 BL2_B_29 BL2_B_30 BL2_B_31 BL2_B_32 BL2_B_33 BL2_B_34 BL2_B_35
+  BL2_B_36 BL2_B_37 BL2_B_38 BL2_B_39 BL2_B_40 BL2_B_41 BL2_B_42 BL2_B_43
+  BL2_B_44 BL2_B_45 BL2_B_46 BL2_B_47 BL2_B_48 BL2_B_49 BL2_B_50 BL2_B_51
+  BL2_B_52 BL2_B_53 BL2_B_54 BL2_B_55 BL2_B_56 BL2_B_57 BL2_B_58 BL2_B_59
+  BL2_B_60 BL2_B_61 BL2_B_62 BL2_B_63 BL2__A_0 BL2__A_1 BL2__A_2 BL2__A_3
+  BL2__A_4 BL2__A_5 BL2__A_6 BL2__A_7 BL2__A_8 BL2__A_9 BL2__A_10 BL2__A_11
+  BL2__A_12 BL2__A_13 BL2__A_14 BL2__A_15 BL2__A_16 BL2__A_17 BL2__A_18
+  BL2__A_19 BL2__A_20 BL2__A_21 BL2__A_22 BL2__A_23 BL2__A_24 BL2__A_25
+  BL2__A_26 BL2__A_27 BL2__A_28 BL2__A_29 BL2__A_30 BL2__A_31 BL2__A_32
+  BL2__A_33 BL2__A_34 BL2__A_35 BL2__A_36 BL2__A_37 BL2__A_38 BL2__A_39
+  BL2__A_40 BL2__A_41 BL2__A_42 BL2__A_43 BL2__A_44 BL2__A_45 BL2__A_46
+  BL2__A_47 BL2__A_48 BL2__A_49 BL2__A_50 BL2__A_51 BL2__A_52 BL2__A_53
+  BL2__A_54 BL2__A_55 BL2__A_56 BL2__A_57 BL2__A_58 BL2__A_59 BL2__A_60
+  BL2__A_61 BL2__A_62 BL2__A_63 BL2__B_0 BL2__B_1 BL2__B_2 BL2__B_3 BL2__B_4
+  BL2__B_5 BL2__B_6 BL2__B_7 BL2__B_8 BL2__B_9 BL2__B_10 BL2__B_11 BL2__B_12
+  BL2__B_13 BL2__B_14 BL2__B_15 BL2__B_16 BL2__B_17 BL2__B_18 BL2__B_19
+  BL2__B_20 BL2__B_21 BL2__B_22 BL2__B_23 BL2__B_24 BL2__B_25 BL2__B_26
+  BL2__B_27 BL2__B_28 BL2__B_29 BL2__B_30 BL2__B_31 BL2__B_32 BL2__B_33
+  BL2__B_34 BL2__B_35 BL2__B_36 BL2__B_37 BL2__B_38 BL2__B_39 BL2__B_40
+  BL2__B_41 BL2__B_42 BL2__B_43 BL2__B_44 BL2__B_45 BL2__B_46 BL2__B_47
+  BL2__B_48 BL2__B_49 BL2__B_50 BL2__B_51 BL2__B_52 BL2__B_53 BL2__B_54
+  BL2__B_55 BL2__B_56 BL2__B_57 BL2__B_58 BL2__B_59 BL2__B_60 BL2__B_61
+  BL2__B_62 BL2__B_63 BL3_A_0 BL3_A_1 BL3_A_2 BL3_A_3 BL3_A_4 BL3_A_5 BL3_A_6
+  BL3_A_7 BL3_A_8 BL3_A_9 BL3_A_10 BL3_A_11 BL3_A_12 BL3_A_13 BL3_A_14
+  BL3_A_15 BL3_A_16 BL3_A_17 BL3_A_18 BL3_A_19 BL3_A_20 BL3_A_21 BL3_A_22
+  BL3_A_23 BL3_A_24 BL3_A_25 BL3_A_26 BL3_A_27 BL3_A_28 BL3_A_29 BL3_A_30
+  BL3_A_31 BL3_A_32 BL3_A_33 BL3_A_34 BL3_A_35 BL3_A_36 BL3_A_37 BL3_A_38
+  BL3_A_39 BL3_A_40 BL3_A_41 BL3_A_42 BL3_A_43 BL3_A_44 BL3_A_45 BL3_A_46
+  BL3_A_47 BL3_A_48 BL3_A_49 BL3_A_50 BL3_A_51 BL3_A_52 BL3_A_53 BL3_A_54
+  BL3_A_55 BL3_A_56 BL3_A_57 BL3_A_58 BL3_A_59 BL3_A_60 BL3_A_61 BL3_A_62
+  BL3_A_63 BL3_B_0 BL3_B_1 BL3_B_2 BL3_B_3 BL3_B_4 BL3_B_5 BL3_B_6 BL3_B_7
+  BL3_B_8 BL3_B_9 BL3_B_10 BL3_B_11 BL3_B_12 BL3_B_13 BL3_B_14 BL3_B_15
+  BL3_B_16 BL3_B_17 BL3_B_18 BL3_B_19 BL3_B_20 BL3_B_21 BL3_B_22 BL3_B_23
+  BL3_B_24 BL3_B_25 BL3_B_26 BL3_B_27 BL3_B_28 BL3_B_29 BL3_B_30 BL3_B_31
+  BL3_B_32 BL3_B_33 BL3_B_34 BL3_B_35 BL3_B_36 BL3_B_37 BL3_B_38 BL3_B_39
+  BL3_B_40 BL3_B_41 BL3_B_42 BL3_B_43 BL3_B_44 BL3_B_45 BL3_B_46 BL3_B_47
+  BL3_B_48 BL3_B_49 BL3_B_50 BL3_B_51 BL3_B_52 BL3_B_53 BL3_B_54 BL3_B_55
+  BL3_B_56 BL3_B_57 BL3_B_58 BL3_B_59 BL3_B_60 BL3_B_61 BL3_B_62 BL3_B_63
+  BL3__A_0 BL3__A_1 BL3__A_2 BL3__A_3 BL3__A_4 BL3__A_5 BL3__A_6 BL3__A_7
+  BL3__A_8 BL3__A_9 BL3__A_10 BL3__A_11 BL3__A_12 BL3__A_13 BL3__A_14
+  BL3__A_15 BL3__A_16 BL3__A_17 BL3__A_18 BL3__A_19 BL3__A_20 BL3__A_21
+  BL3__A_22 BL3__A_23 BL3__A_24 BL3__A_25 BL3__A_26 BL3__A_27 BL3__A_28
+  BL3__A_29 BL3__A_30 BL3__A_31 BL3__A_32 BL3__A_33 BL3__A_34 BL3__A_35
+  BL3__A_36 BL3__A_37 BL3__A_38 BL3__A_39 BL3__A_40 BL3__A_41 BL3__A_42
+  BL3__A_43 BL3__A_44 BL3__A_45 BL3__A_46 BL3__A_47 BL3__A_48 BL3__A_49
+  BL3__A_50 BL3__A_51 BL3__A_52 BL3__A_53 BL3__A_54 BL3__A_55 BL3__A_56
+  BL3__A_57 BL3__A_58 BL3__A_59 BL3__A_60 BL3__A_61 BL3__A_62 BL3__A_63
+  BL3__B_0 BL3__B_1 BL3__B_2 BL3__B_3 BL3__B_4 BL3__B_5 BL3__B_6 BL3__B_7
+  BL3__B_8 BL3__B_9 BL3__B_10 BL3__B_11 BL3__B_12 BL3__B_13 BL3__B_14
+  BL3__B_15 BL3__B_16 BL3__B_17 BL3__B_18 BL3__B_19 BL3__B_20 BL3__B_21
+  BL3__B_22 BL3__B_23 BL3__B_24 BL3__B_25 BL3__B_26 BL3__B_27 BL3__B_28
+  BL3__B_29 BL3__B_30 BL3__B_31 BL3__B_32 BL3__B_33 BL3__B_34 BL3__B_35
+  BL3__B_36 BL3__B_37 BL3__B_38 BL3__B_39 BL3__B_40 BL3__B_41 BL3__B_42
+  BL3__B_43 BL3__B_44 BL3__B_45 BL3__B_46 BL3__B_47 BL3__B_48 BL3__B_49
+  BL3__B_50 BL3__B_51 BL3__B_52 BL3__B_53 BL3__B_54 BL3__B_55 BL3__B_56
+  BL3__B_57 BL3__B_58 BL3__B_59 BL3__B_60 BL3__B_61 BL3__B_62 BL3__B_63 VSSE
+  VSSE BS0N_0 BS0N_1 VSSE VSSE BS1N_0 BS1N_1 VSSE VSSE BS2N_0 BS2N_1 BTPWDT_0
+  BTPWDT_1 VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE GDL_0 GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9
+  GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19
+  GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29
+  GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39
+  GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49
+  GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59
+  GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65 GDL_66 GDL_67 GDL_68 GDL_69
+  GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75 GDL_76 GDL_77 GDL_78 GDL_79
+  GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85 GDL_86 GDL_87 GDL_88 GDL_89
+  GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95 GDL_96 GDL_97 GDL_98 GDL_99
+  GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105 GDL_106 GDL_107 GDL_108
+  GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114 GDL_115 GDL_116 GDL_117
+  GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123 GDL_124 GDL_125 GDL_126
+  GDL_127 GDL__0 GDL__1 GDL__2 GDL__3 GDL__4 GDL__5 GDL__6 GDL__7 GDL__8
+  GDL__9 GDL__10 GDL__11 GDL__12 GDL__13 GDL__14 GDL__15 GDL__16 GDL__17
+  GDL__18 GDL__19 GDL__20 GDL__21 GDL__22 GDL__23 GDL__24 GDL__25 GDL__26
+  GDL__27 GDL__28 GDL__29 GDL__30 GDL__31 GDL__32 GDL__33 GDL__34 GDL__35
+  GDL__36 GDL__37 GDL__38 GDL__39 GDL__40 GDL__41 GDL__42 GDL__43 GDL__44
+  GDL__45 GDL__46 GDL__47 GDL__48 GDL__49 GDL__50 GDL__51 GDL__52 GDL__53
+  GDL__54 GDL__55 GDL__56 GDL__57 GDL__58 GDL__59 GDL__60 GDL__61 GDL__62
+  GDL__63 GDL__64 GDL__65 GDL__66 GDL__67 GDL__68 GDL__69 GDL__70 GDL__71
+  GDL__72 GDL__73 GDL__74 GDL__75 GDL__76 GDL__77 GDL__78 GDL__79 GDL__80
+  GDL__81 GDL__82 GDL__83 GDL__84 GDL__85 GDL__86 GDL__87 GDL__88 GDL__89
+  GDL__90 GDL__91 GDL__92 GDL__93 GDL__94 GDL__95 GDL__96 GDL__97 GDL__98
+  GDL__99 GDL__100 GDL__101 GDL__102 GDL__103 GDL__104 GDL__105 GDL__106
+  GDL__107 GDL__108 GDL__109 GDL__110 GDL__111 GDL__112 GDL__113 GDL__114
+  GDL__115 GDL__116 GDL__117 GDL__118 GDL__119 GDL__120 GDL__121 GDL__122
+  GDL__123 GDL__124 GDL__125 GDL__126 GDL__127 VSSE VSSE VSSE VSSE GTPD_0
+  GTPD_1 GTP_0 GTP_1 LGWE_0 LGWE_1 MBL_0 MBL_1 VSSE VSSE MGDLE_0 MGDLE_1 VSSE
+  VSSE MGTPST_0 MGTPST_1 MGTPS_0 MGTPS_1 RBTPT_0 RBTPT_1 RDTN_0 RDTN_1 RET_0
+  RET_1 RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0 RRA1_1 RRA1__0 RRA1__1 VSSE VSSE
+  RREN_0 RREN_1 TIEHI TIEHI TIELO TIELO WBT_0 WBT_1 XP0_0 XP0_1 XP1_0 XP1_1
+  XP2_0 XP2_1 XP3_0 XP3_1 XP4_0 XP4_1 XP5_0 XP5_1 XP6_0 XP6_1 XP7_0 XP7_1
+  XP8_0 XP8_1 XP9_0 XP9_1 XP10_0 XP10_1 XP11_0 XP11_1 XP12_0 XP12_1 XP13_0
+  XP13_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpCHANNEL_0
XI0_1 AX0TRACK_0 AX0TRACK_1 AX1TRACK_0 AX1TRACK_1 AX2TRACK_0 AX2TRACK_1
+  AX3TRACK_0 AX3TRACK_1 AX4TRACK_0 AX4TRACK_1 AX5TRACK_0 AX5TRACK_1
+  AY0TRACK_0 AY0TRACK_1 AY1TRACK_0 AY1TRACK_1 BL0_A_0 BL1_A_0 BL2_A_0 BL3_A_0
+  BL3_A_1 BL2_A_1 BL1_A_1 BL0_A_1 BL0_A_2 BL1_A_2 BL2_A_2 BL3_A_2 BL3_A_3
+  BL2_A_3 BL1_A_3 BL0_A_3 BL0_A_4 BL1_A_4 BL2_A_4 BL3_A_4 BL3_A_5 BL2_A_5
+  BL1_A_5 BL0_A_5 BL0_A_6 BL1_A_6 BL2_A_6 BL3_A_6 BL3_A_7 BL2_A_7 BL1_A_7
+  BL0_A_7 BL0_A_8 BL1_A_8 BL2_A_8 BL3_A_8 BL3_A_9 BL2_A_9 BL1_A_9 BL0_A_9
+  BL0_A_10 BL1_A_10 BL2_A_10 BL3_A_10 BL3_A_11 BL2_A_11 BL1_A_11 BL0_A_11
+  BL0_A_12 BL1_A_12 BL2_A_12 BL3_A_12 BL3_A_13 BL2_A_13 BL1_A_13 BL0_A_13
+  BL0_A_14 BL1_A_14 BL2_A_14 BL3_A_14 BL3_A_15 BL2_A_15 BL1_A_15 BL0_A_15
+  BL0_A_16 BL1_A_16 BL2_A_16 BL3_A_16 BL3_A_17 BL2_A_17 BL1_A_17 BL0_A_17
+  BL0_A_18 BL1_A_18 BL2_A_18 BL3_A_18 BL3_A_19 BL2_A_19 BL1_A_19 BL0_A_19
+  BL0_A_20 BL1_A_20 BL2_A_20 BL3_A_20 BL3_A_21 BL2_A_21 BL1_A_21 BL0_A_21
+  BL0_A_22 BL1_A_22 BL2_A_22 BL3_A_22 BL3_A_23 BL2_A_23 BL1_A_23 BL0_A_23
+  BL0_A_24 BL1_A_24 BL2_A_24 BL3_A_24 BL3_A_25 BL2_A_25 BL1_A_25 BL0_A_25
+  BL0_A_26 BL1_A_26 BL2_A_26 BL3_A_26 BL3_A_27 BL2_A_27 BL1_A_27 BL0_A_27
+  BL0_A_28 BL1_A_28 BL2_A_28 BL3_A_28 BL3_A_29 BL2_A_29 BL1_A_29 BL0_A_29
+  BL0_A_30 BL1_A_30 BL2_A_30 BL3_A_30 BL3_A_31 BL2_A_31 BL1_A_31 BL0_A_31
+  VDDCE VDDCE BL0_A_32 BL1_A_32 BL2_A_32 BL3_A_32 BL3_A_33 BL2_A_33 BL1_A_33
+  BL0_A_33 BL0_A_34 BL1_A_34 BL2_A_34 BL3_A_34 BL3_A_35 BL2_A_35 BL1_A_35
+  BL0_A_35 BL0_A_36 BL1_A_36 BL2_A_36 BL3_A_36 BL3_A_37 BL2_A_37 BL1_A_37
+  BL0_A_37 BL0_A_38 BL1_A_38 BL2_A_38 BL3_A_38 BL3_A_39 BL2_A_39 BL1_A_39
+  BL0_A_39 BL0_A_40 BL1_A_40 BL2_A_40 BL3_A_40 BL3_A_41 BL2_A_41 BL1_A_41
+  BL0_A_41 BL0_A_42 BL1_A_42 BL2_A_42 BL3_A_42 BL3_A_43 BL2_A_43 BL1_A_43
+  BL0_A_43 BL0_A_44 BL1_A_44 BL2_A_44 BL3_A_44 BL3_A_45 BL2_A_45 BL1_A_45
+  BL0_A_45 BL0_A_46 BL1_A_46 BL2_A_46 BL3_A_46 BL3_A_47 BL2_A_47 BL1_A_47
+  BL0_A_47 BL0_A_48 BL1_A_48 BL2_A_48 BL3_A_48 BL3_A_49 BL2_A_49 BL1_A_49
+  BL0_A_49 BL0_A_50 BL1_A_50 BL2_A_50 BL3_A_50 BL3_A_51 BL2_A_51 BL1_A_51
+  BL0_A_51 BL0_A_52 BL1_A_52 BL2_A_52 BL3_A_52 BL3_A_53 BL2_A_53 BL1_A_53
+  BL0_A_53 BL0_A_54 BL1_A_54 BL2_A_54 BL3_A_54 BL3_A_55 BL2_A_55 BL1_A_55
+  BL0_A_55 BL0_A_56 BL1_A_56 BL2_A_56 BL3_A_56 BL3_A_57 BL2_A_57 BL1_A_57
+  BL0_A_57 BL0_A_58 BL1_A_58 BL2_A_58 BL3_A_58 BL3_A_59 BL2_A_59 BL1_A_59
+  BL0_A_59 BL0_A_60 BL1_A_60 BL2_A_60 BL3_A_60 BL3_A_61 BL2_A_61 BL1_A_61
+  BL0_A_61 BL0_A_62 BL1_A_62 BL2_A_62 BL3_A_62 BL3_A_63 BL2_A_63 BL1_A_63
+  BL0_A_63 BL0__A_0 BL1__A_0 BL2__A_0 BL3__A_0 BL3__A_1 BL2__A_1 BL1__A_1
+  BL0__A_1 BL0__A_2 BL1__A_2 BL2__A_2 BL3__A_2 BL3__A_3 BL2__A_3 BL1__A_3
+  BL0__A_3 BL0__A_4 BL1__A_4 BL2__A_4 BL3__A_4 BL3__A_5 BL2__A_5 BL1__A_5
+  BL0__A_5 BL0__A_6 BL1__A_6 BL2__A_6 BL3__A_6 BL3__A_7 BL2__A_7 BL1__A_7
+  BL0__A_7 BL0__A_8 BL1__A_8 BL2__A_8 BL3__A_8 BL3__A_9 BL2__A_9 BL1__A_9
+  BL0__A_9 BL0__A_10 BL1__A_10 BL2__A_10 BL3__A_10 BL3__A_11 BL2__A_11
+  BL1__A_11 BL0__A_11 BL0__A_12 BL1__A_12 BL2__A_12 BL3__A_12 BL3__A_13
+  BL2__A_13 BL1__A_13 BL0__A_13 BL0__A_14 BL1__A_14 BL2__A_14 BL3__A_14
+  BL3__A_15 BL2__A_15 BL1__A_15 BL0__A_15 BL0__A_16 BL1__A_16 BL2__A_16
+  BL3__A_16 BL3__A_17 BL2__A_17 BL1__A_17 BL0__A_17 BL0__A_18 BL1__A_18
+  BL2__A_18 BL3__A_18 BL3__A_19 BL2__A_19 BL1__A_19 BL0__A_19 BL0__A_20
+  BL1__A_20 BL2__A_20 BL3__A_20 BL3__A_21 BL2__A_21 BL1__A_21 BL0__A_21
+  BL0__A_22 BL1__A_22 BL2__A_22 BL3__A_22 BL3__A_23 BL2__A_23 BL1__A_23
+  BL0__A_23 BL0__A_24 BL1__A_24 BL2__A_24 BL3__A_24 BL3__A_25 BL2__A_25
+  BL1__A_25 BL0__A_25 BL0__A_26 BL1__A_26 BL2__A_26 BL3__A_26 BL3__A_27
+  BL2__A_27 BL1__A_27 BL0__A_27 BL0__A_28 BL1__A_28 BL2__A_28 BL3__A_28
+  BL3__A_29 BL2__A_29 BL1__A_29 BL0__A_29 BL0__A_30 BL1__A_30 BL2__A_30
+  BL3__A_30 BL3__A_31 BL2__A_31 BL1__A_31 BL0__A_31 VSSE VSSE BL0__A_32
+  BL1__A_32 BL2__A_32 BL3__A_32 BL3__A_33 BL2__A_33 BL1__A_33 BL0__A_33
+  BL0__A_34 BL1__A_34 BL2__A_34 BL3__A_34 BL3__A_35 BL2__A_35 BL1__A_35
+  BL0__A_35 BL0__A_36 BL1__A_36 BL2__A_36 BL3__A_36 BL3__A_37 BL2__A_37
+  BL1__A_37 BL0__A_37 BL0__A_38 BL1__A_38 BL2__A_38 BL3__A_38 BL3__A_39
+  BL2__A_39 BL1__A_39 BL0__A_39 BL0__A_40 BL1__A_40 BL2__A_40 BL3__A_40
+  BL3__A_41 BL2__A_41 BL1__A_41 BL0__A_41 BL0__A_42 BL1__A_42 BL2__A_42
+  BL3__A_42 BL3__A_43 BL2__A_43 BL1__A_43 BL0__A_43 BL0__A_44 BL1__A_44
+  BL2__A_44 BL3__A_44 BL3__A_45 BL2__A_45 BL1__A_45 BL0__A_45 BL0__A_46
+  BL1__A_46 BL2__A_46 BL3__A_46 BL3__A_47 BL2__A_47 BL1__A_47 BL0__A_47
+  BL0__A_48 BL1__A_48 BL2__A_48 BL3__A_48 BL3__A_49 BL2__A_49 BL1__A_49
+  BL0__A_49 BL0__A_50 BL1__A_50 BL2__A_50 BL3__A_50 BL3__A_51 BL2__A_51
+  BL1__A_51 BL0__A_51 BL0__A_52 BL1__A_52 BL2__A_52 BL3__A_52 BL3__A_53
+  BL2__A_53 BL1__A_53 BL0__A_53 BL0__A_54 BL1__A_54 BL2__A_54 BL3__A_54
+  BL3__A_55 BL2__A_55 BL1__A_55 BL0__A_55 BL0__A_56 BL1__A_56 BL2__A_56
+  BL3__A_56 BL3__A_57 BL2__A_57 BL1__A_57 BL0__A_57 BL0__A_58 BL1__A_58
+  BL2__A_58 BL3__A_58 BL3__A_59 BL2__A_59 BL1__A_59 BL0__A_59 BL0__A_60
+  BL1__A_60 BL2__A_60 BL3__A_60 BL3__A_61 BL2__A_61 BL1__A_61 BL0__A_61
+  BL0__A_62 BL1__A_62 BL2__A_62 BL3__A_62 BL3__A_63 BL2__A_63 BL1__A_63
+  BL0__A_63 BL0_B_0 BL1_B_0 BL2_B_0 BL3_B_0 BL3_B_1 BL2_B_1 BL1_B_1 BL0_B_1
+  BL0_B_2 BL1_B_2 BL2_B_2 BL3_B_2 BL3_B_3 BL2_B_3 BL1_B_3 BL0_B_3 BL0_B_4
+  BL1_B_4 BL2_B_4 BL3_B_4 BL3_B_5 BL2_B_5 BL1_B_5 BL0_B_5 BL0_B_6 BL1_B_6
+  BL2_B_6 BL3_B_6 BL3_B_7 BL2_B_7 BL1_B_7 BL0_B_7 BL0_B_8 BL1_B_8 BL2_B_8
+  BL3_B_8 BL3_B_9 BL2_B_9 BL1_B_9 BL0_B_9 BL0_B_10 BL1_B_10 BL2_B_10 BL3_B_10
+  BL3_B_11 BL2_B_11 BL1_B_11 BL0_B_11 BL0_B_12 BL1_B_12 BL2_B_12 BL3_B_12
+  BL3_B_13 BL2_B_13 BL1_B_13 BL0_B_13 BL0_B_14 BL1_B_14 BL2_B_14 BL3_B_14
+  BL3_B_15 BL2_B_15 BL1_B_15 BL0_B_15 BL0_B_16 BL1_B_16 BL2_B_16 BL3_B_16
+  BL3_B_17 BL2_B_17 BL1_B_17 BL0_B_17 BL0_B_18 BL1_B_18 BL2_B_18 BL3_B_18
+  BL3_B_19 BL2_B_19 BL1_B_19 BL0_B_19 BL0_B_20 BL1_B_20 BL2_B_20 BL3_B_20
+  BL3_B_21 BL2_B_21 BL1_B_21 BL0_B_21 BL0_B_22 BL1_B_22 BL2_B_22 BL3_B_22
+  BL3_B_23 BL2_B_23 BL1_B_23 BL0_B_23 BL0_B_24 BL1_B_24 BL2_B_24 BL3_B_24
+  BL3_B_25 BL2_B_25 BL1_B_25 BL0_B_25 BL0_B_26 BL1_B_26 BL2_B_26 BL3_B_26
+  BL3_B_27 BL2_B_27 BL1_B_27 BL0_B_27 BL0_B_28 BL1_B_28 BL2_B_28 BL3_B_28
+  BL3_B_29 BL2_B_29 BL1_B_29 BL0_B_29 BL0_B_30 BL1_B_30 BL2_B_30 BL3_B_30
+  BL3_B_31 BL2_B_31 BL1_B_31 BL0_B_31 BL0_B_32 BL1_B_32 BL2_B_32 BL3_B_32
+  BL3_B_33 BL2_B_33 BL1_B_33 BL0_B_33 BL0_B_34 BL1_B_34 BL2_B_34 BL3_B_34
+  BL3_B_35 BL2_B_35 BL1_B_35 BL0_B_35 BL0_B_36 BL1_B_36 BL2_B_36 BL3_B_36
+  BL3_B_37 BL2_B_37 BL1_B_37 BL0_B_37 BL0_B_38 BL1_B_38 BL2_B_38 BL3_B_38
+  BL3_B_39 BL2_B_39 BL1_B_39 BL0_B_39 BL0_B_40 BL1_B_40 BL2_B_40 BL3_B_40
+  BL3_B_41 BL2_B_41 BL1_B_41 BL0_B_41 BL0_B_42 BL1_B_42 BL2_B_42 BL3_B_42
+  BL3_B_43 BL2_B_43 BL1_B_43 BL0_B_43 BL0_B_44 BL1_B_44 BL2_B_44 BL3_B_44
+  BL3_B_45 BL2_B_45 BL1_B_45 BL0_B_45 BL0_B_46 BL1_B_46 BL2_B_46 BL3_B_46
+  BL3_B_47 BL2_B_47 BL1_B_47 BL0_B_47 BL0_B_48 BL1_B_48 BL2_B_48 BL3_B_48
+  BL3_B_49 BL2_B_49 BL1_B_49 BL0_B_49 BL0_B_50 BL1_B_50 BL2_B_50 BL3_B_50
+  BL3_B_51 BL2_B_51 BL1_B_51 BL0_B_51 BL0_B_52 BL1_B_52 BL2_B_52 BL3_B_52
+  BL3_B_53 BL2_B_53 BL1_B_53 BL0_B_53 BL0_B_54 BL1_B_54 BL2_B_54 BL3_B_54
+  BL3_B_55 BL2_B_55 BL1_B_55 BL0_B_55 BL0_B_56 BL1_B_56 BL2_B_56 BL3_B_56
+  BL3_B_57 BL2_B_57 BL1_B_57 BL0_B_57 BL0_B_58 BL1_B_58 BL2_B_58 BL3_B_58
+  BL3_B_59 BL2_B_59 BL1_B_59 BL0_B_59 BL0_B_60 BL1_B_60 BL2_B_60 BL3_B_60
+  BL3_B_61 BL2_B_61 BL1_B_61 BL0_B_61 BL0_B_62 BL1_B_62 BL2_B_62 BL3_B_62
+  BL3_B_63 BL2_B_63 BL1_B_63 BL0_B_63 BL0__B_0 BL1__B_0 BL2__B_0 BL3__B_0
+  BL3__B_1 BL2__B_1 BL1__B_1 BL0__B_1 BL0__B_2 BL1__B_2 BL2__B_2 BL3__B_2
+  BL3__B_3 BL2__B_3 BL1__B_3 BL0__B_3 BL0__B_4 BL1__B_4 BL2__B_4 BL3__B_4
+  BL3__B_5 BL2__B_5 BL1__B_5 BL0__B_5 BL0__B_6 BL1__B_6 BL2__B_6 BL3__B_6
+  BL3__B_7 BL2__B_7 BL1__B_7 BL0__B_7 BL0__B_8 BL1__B_8 BL2__B_8 BL3__B_8
+  BL3__B_9 BL2__B_9 BL1__B_9 BL0__B_9 BL0__B_10 BL1__B_10 BL2__B_10 BL3__B_10
+  BL3__B_11 BL2__B_11 BL1__B_11 BL0__B_11 BL0__B_12 BL1__B_12 BL2__B_12
+  BL3__B_12 BL3__B_13 BL2__B_13 BL1__B_13 BL0__B_13 BL0__B_14 BL1__B_14
+  BL2__B_14 BL3__B_14 BL3__B_15 BL2__B_15 BL1__B_15 BL0__B_15 BL0__B_16
+  BL1__B_16 BL2__B_16 BL3__B_16 BL3__B_17 BL2__B_17 BL1__B_17 BL0__B_17
+  BL0__B_18 BL1__B_18 BL2__B_18 BL3__B_18 BL3__B_19 BL2__B_19 BL1__B_19
+  BL0__B_19 BL0__B_20 BL1__B_20 BL2__B_20 BL3__B_20 BL3__B_21 BL2__B_21
+  BL1__B_21 BL0__B_21 BL0__B_22 BL1__B_22 BL2__B_22 BL3__B_22 BL3__B_23
+  BL2__B_23 BL1__B_23 BL0__B_23 BL0__B_24 BL1__B_24 BL2__B_24 BL3__B_24
+  BL3__B_25 BL2__B_25 BL1__B_25 BL0__B_25 BL0__B_26 BL1__B_26 BL2__B_26
+  BL3__B_26 BL3__B_27 BL2__B_27 BL1__B_27 BL0__B_27 BL0__B_28 BL1__B_28
+  BL2__B_28 BL3__B_28 BL3__B_29 BL2__B_29 BL1__B_29 BL0__B_29 BL0__B_30
+  BL1__B_30 BL2__B_30 BL3__B_30 BL3__B_31 BL2__B_31 BL1__B_31 BL0__B_31 VSSE
+  VSSE BL0__B_32 BL1__B_32 BL2__B_32 BL3__B_32 BL3__B_33 BL2__B_33 BL1__B_33
+  BL0__B_33 BL0__B_34 BL1__B_34 BL2__B_34 BL3__B_34 BL3__B_35 BL2__B_35
+  BL1__B_35 BL0__B_35 BL0__B_36 BL1__B_36 BL2__B_36 BL3__B_36 BL3__B_37
+  BL2__B_37 BL1__B_37 BL0__B_37 BL0__B_38 BL1__B_38 BL2__B_38 BL3__B_38
+  BL3__B_39 BL2__B_39 BL1__B_39 BL0__B_39 BL0__B_40 BL1__B_40 BL2__B_40
+  BL3__B_40 BL3__B_41 BL2__B_41 BL1__B_41 BL0__B_41 BL0__B_42 BL1__B_42
+  BL2__B_42 BL3__B_42 BL3__B_43 BL2__B_43 BL1__B_43 BL0__B_43 BL0__B_44
+  BL1__B_44 BL2__B_44 BL3__B_44 BL3__B_45 BL2__B_45 BL1__B_45 BL0__B_45
+  BL0__B_46 BL1__B_46 BL2__B_46 BL3__B_46 BL3__B_47 BL2__B_47 BL1__B_47
+  BL0__B_47 BL0__B_48 BL1__B_48 BL2__B_48 BL3__B_48 BL3__B_49 BL2__B_49
+  BL1__B_49 BL0__B_49 BL0__B_50 BL1__B_50 BL2__B_50 BL3__B_50 BL3__B_51
+  BL2__B_51 BL1__B_51 BL0__B_51 BL0__B_52 BL1__B_52 BL2__B_52 BL3__B_52
+  BL3__B_53 BL2__B_53 BL1__B_53 BL0__B_53 BL0__B_54 BL1__B_54 BL2__B_54
+  BL3__B_54 BL3__B_55 BL2__B_55 BL1__B_55 BL0__B_55 BL0__B_56 BL1__B_56
+  BL2__B_56 BL3__B_56 BL3__B_57 BL2__B_57 BL1__B_57 BL0__B_57 BL0__B_58
+  BL1__B_58 BL2__B_58 BL3__B_58 BL3__B_59 BL2__B_59 BL1__B_59 BL0__B_59
+  BL0__B_60 BL1__B_60 BL2__B_60 BL3__B_60 BL3__B_61 BL2__B_61 BL1__B_61
+  BL0__B_61 BL0__B_62 BL1__B_62 BL2__B_62 BL3__B_62 BL3__B_63 BL2__B_63
+  BL1__B_63 BL0__B_63 VSSE VSSE VSSE VSSE VSSE VSSE BTPWDT_0 BTPWDT_1 VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE GTP_0 GTP_1 VSSE VSSE LGWE_0 LGWE_1
+  MBL_0_1060 MBL_1_1058 MBL_0 MBL_1 VSSE VSSE VSSE VSSE VSSE VSSE MGTPST_0
+  MGTPST_1 VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE
+  VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VSSE VSSE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE
+  VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VSSE VSSE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE RBTPT_0
+  RBTPT_1 RDTN_0 RDTN_1 RET_0 RET_1 RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0
+  RRA1_1 RRA1__0 RRA1__1 VSSE VSSE TIEHI TIELO WBT_0 WBT_1 XP0_0 XP0_1 XP1_0
+  XP1_1 XP2_0 XP2_1 XP3_0 XP3_1 XP4_0 XP4_1 XP5_0 XP5_1 XP6_0 XP6_1 XP7_0
+  XP7_1 XP8_0 XP8_1 XP9_0 XP9_1 XP10_0 XP10_1 XP11_0 XP11_1 XP12_0 XP12_1
+  XP13_0 XP13_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpMODEL_ROW
XI0_2 AX0TRACK_0 AX0TRACK_1 AX1TRACK_0 AX1TRACK_1 AX2TRACK_0 AX2TRACK_1
+  AX3TRACK_0 AX3TRACK_1 AX4TRACK_0 AX4TRACK_1 AX5TRACK_0 AX5TRACK_1
+  AY0TRACK_0 AY0TRACK_1 AY1TRACK_0 AY1TRACK_1 BL0_A_0 BL1_A_0 BL2_A_0 BL3_A_0
+  BL3_A_1 BL2_A_1 BL1_A_1 BL0_A_1 BL0_A_2 BL1_A_2 BL2_A_2 BL3_A_2 BL3_A_3
+  BL2_A_3 BL1_A_3 BL0_A_3 BL0_A_4 BL1_A_4 BL2_A_4 BL3_A_4 BL3_A_5 BL2_A_5
+  BL1_A_5 BL0_A_5 BL0_A_6 BL1_A_6 BL2_A_6 BL3_A_6 BL3_A_7 BL2_A_7 BL1_A_7
+  BL0_A_7 BL0_A_8 BL1_A_8 BL2_A_8 BL3_A_8 BL3_A_9 BL2_A_9 BL1_A_9 BL0_A_9
+  BL0_A_10 BL1_A_10 BL2_A_10 BL3_A_10 BL3_A_11 BL2_A_11 BL1_A_11 BL0_A_11
+  BL0_A_12 BL1_A_12 BL2_A_12 BL3_A_12 BL3_A_13 BL2_A_13 BL1_A_13 BL0_A_13
+  BL0_A_14 BL1_A_14 BL2_A_14 BL3_A_14 BL3_A_15 BL2_A_15 BL1_A_15 BL0_A_15
+  BL0_A_16 BL1_A_16 BL2_A_16 BL3_A_16 BL3_A_17 BL2_A_17 BL1_A_17 BL0_A_17
+  BL0_A_18 BL1_A_18 BL2_A_18 BL3_A_18 BL3_A_19 BL2_A_19 BL1_A_19 BL0_A_19
+  BL0_A_20 BL1_A_20 BL2_A_20 BL3_A_20 BL3_A_21 BL2_A_21 BL1_A_21 BL0_A_21
+  BL0_A_22 BL1_A_22 BL2_A_22 BL3_A_22 BL3_A_23 BL2_A_23 BL1_A_23 BL0_A_23
+  BL0_A_24 BL1_A_24 BL2_A_24 BL3_A_24 BL3_A_25 BL2_A_25 BL1_A_25 BL0_A_25
+  BL0_A_26 BL1_A_26 BL2_A_26 BL3_A_26 BL3_A_27 BL2_A_27 BL1_A_27 BL0_A_27
+  BL0_A_28 BL1_A_28 BL2_A_28 BL3_A_28 BL3_A_29 BL2_A_29 BL1_A_29 BL0_A_29
+  BL0_A_30 BL1_A_30 BL2_A_30 BL3_A_30 BL3_A_31 BL2_A_31 BL1_A_31 BL0_A_31
+  BL0_A_32 BL1_A_32 BL2_A_32 BL3_A_32 BL3_A_33 BL2_A_33 BL1_A_33 BL0_A_33
+  BL0_A_34 BL1_A_34 BL2_A_34 BL3_A_34 BL3_A_35 BL2_A_35 BL1_A_35 BL0_A_35
+  BL0_A_36 BL1_A_36 BL2_A_36 BL3_A_36 BL3_A_37 BL2_A_37 BL1_A_37 BL0_A_37
+  BL0_A_38 BL1_A_38 BL2_A_38 BL3_A_38 BL3_A_39 BL2_A_39 BL1_A_39 BL0_A_39
+  BL0_A_40 BL1_A_40 BL2_A_40 BL3_A_40 BL3_A_41 BL2_A_41 BL1_A_41 BL0_A_41
+  BL0_A_42 BL1_A_42 BL2_A_42 BL3_A_42 BL3_A_43 BL2_A_43 BL1_A_43 BL0_A_43
+  BL0_A_44 BL1_A_44 BL2_A_44 BL3_A_44 BL3_A_45 BL2_A_45 BL1_A_45 BL0_A_45
+  BL0_A_46 BL1_A_46 BL2_A_46 BL3_A_46 BL3_A_47 BL2_A_47 BL1_A_47 BL0_A_47
+  BL0_A_48 BL1_A_48 BL2_A_48 BL3_A_48 BL3_A_49 BL2_A_49 BL1_A_49 BL0_A_49
+  BL0_A_50 BL1_A_50 BL2_A_50 BL3_A_50 BL3_A_51 BL2_A_51 BL1_A_51 BL0_A_51
+  BL0_A_52 BL1_A_52 BL2_A_52 BL3_A_52 BL3_A_53 BL2_A_53 BL1_A_53 BL0_A_53
+  BL0_A_54 BL1_A_54 BL2_A_54 BL3_A_54 BL3_A_55 BL2_A_55 BL1_A_55 BL0_A_55
+  BL0_A_56 BL1_A_56 BL2_A_56 BL3_A_56 BL3_A_57 BL2_A_57 BL1_A_57 BL0_A_57
+  BL0_A_58 BL1_A_58 BL2_A_58 BL3_A_58 BL3_A_59 BL2_A_59 BL1_A_59 BL0_A_59
+  BL0_A_60 BL1_A_60 BL2_A_60 BL3_A_60 BL3_A_61 BL2_A_61 BL1_A_61 BL0_A_61
+  BL0_A_62 BL1_A_62 BL2_A_62 BL3_A_62 BL3_A_63 BL2_A_63 BL1_A_63 BL0_A_63
+  BL0__A_0 BL1__A_0 BL2__A_0 BL3__A_0 BL3__A_1 BL2__A_1 BL1__A_1 BL0__A_1
+  BL0__A_2 BL1__A_2 BL2__A_2 BL3__A_2 BL3__A_3 BL2__A_3 BL1__A_3 BL0__A_3
+  BL0__A_4 BL1__A_4 BL2__A_4 BL3__A_4 BL3__A_5 BL2__A_5 BL1__A_5 BL0__A_5
+  BL0__A_6 BL1__A_6 BL2__A_6 BL3__A_6 BL3__A_7 BL2__A_7 BL1__A_7 BL0__A_7
+  BL0__A_8 BL1__A_8 BL2__A_8 BL3__A_8 BL3__A_9 BL2__A_9 BL1__A_9 BL0__A_9
+  BL0__A_10 BL1__A_10 BL2__A_10 BL3__A_10 BL3__A_11 BL2__A_11 BL1__A_11
+  BL0__A_11 BL0__A_12 BL1__A_12 BL2__A_12 BL3__A_12 BL3__A_13 BL2__A_13
+  BL1__A_13 BL0__A_13 BL0__A_14 BL1__A_14 BL2__A_14 BL3__A_14 BL3__A_15
+  BL2__A_15 BL1__A_15 BL0__A_15 BL0__A_16 BL1__A_16 BL2__A_16 BL3__A_16
+  BL3__A_17 BL2__A_17 BL1__A_17 BL0__A_17 BL0__A_18 BL1__A_18 BL2__A_18
+  BL3__A_18 BL3__A_19 BL2__A_19 BL1__A_19 BL0__A_19 BL0__A_20 BL1__A_20
+  BL2__A_20 BL3__A_20 BL3__A_21 BL2__A_21 BL1__A_21 BL0__A_21 BL0__A_22
+  BL1__A_22 BL2__A_22 BL3__A_22 BL3__A_23 BL2__A_23 BL1__A_23 BL0__A_23
+  BL0__A_24 BL1__A_24 BL2__A_24 BL3__A_24 BL3__A_25 BL2__A_25 BL1__A_25
+  BL0__A_25 BL0__A_26 BL1__A_26 BL2__A_26 BL3__A_26 BL3__A_27 BL2__A_27
+  BL1__A_27 BL0__A_27 BL0__A_28 BL1__A_28 BL2__A_28 BL3__A_28 BL3__A_29
+  BL2__A_29 BL1__A_29 BL0__A_29 BL0__A_30 BL1__A_30 BL2__A_30 BL3__A_30
+  BL3__A_31 BL2__A_31 BL1__A_31 BL0__A_31 BL0__A_32 BL1__A_32 BL2__A_32
+  BL3__A_32 BL3__A_33 BL2__A_33 BL1__A_33 BL0__A_33 BL0__A_34 BL1__A_34
+  BL2__A_34 BL3__A_34 BL3__A_35 BL2__A_35 BL1__A_35 BL0__A_35 BL0__A_36
+  BL1__A_36 BL2__A_36 BL3__A_36 BL3__A_37 BL2__A_37 BL1__A_37 BL0__A_37
+  BL0__A_38 BL1__A_38 BL2__A_38 BL3__A_38 BL3__A_39 BL2__A_39 BL1__A_39
+  BL0__A_39 BL0__A_40 BL1__A_40 BL2__A_40 BL3__A_40 BL3__A_41 BL2__A_41
+  BL1__A_41 BL0__A_41 BL0__A_42 BL1__A_42 BL2__A_42 BL3__A_42 BL3__A_43
+  BL2__A_43 BL1__A_43 BL0__A_43 BL0__A_44 BL1__A_44 BL2__A_44 BL3__A_44
+  BL3__A_45 BL2__A_45 BL1__A_45 BL0__A_45 BL0__A_46 BL1__A_46 BL2__A_46
+  BL3__A_46 BL3__A_47 BL2__A_47 BL1__A_47 BL0__A_47 BL0__A_48 BL1__A_48
+  BL2__A_48 BL3__A_48 BL3__A_49 BL2__A_49 BL1__A_49 BL0__A_49 BL0__A_50
+  BL1__A_50 BL2__A_50 BL3__A_50 BL3__A_51 BL2__A_51 BL1__A_51 BL0__A_51
+  BL0__A_52 BL1__A_52 BL2__A_52 BL3__A_52 BL3__A_53 BL2__A_53 BL1__A_53
+  BL0__A_53 BL0__A_54 BL1__A_54 BL2__A_54 BL3__A_54 BL3__A_55 BL2__A_55
+  BL1__A_55 BL0__A_55 BL0__A_56 BL1__A_56 BL2__A_56 BL3__A_56 BL3__A_57
+  BL2__A_57 BL1__A_57 BL0__A_57 BL0__A_58 BL1__A_58 BL2__A_58 BL3__A_58
+  BL3__A_59 BL2__A_59 BL1__A_59 BL0__A_59 BL0__A_60 BL1__A_60 BL2__A_60
+  BL3__A_60 BL3__A_61 BL2__A_61 BL1__A_61 BL0__A_61 BL0__A_62 BL1__A_62
+  BL2__A_62 BL3__A_62 BL3__A_63 BL2__A_63 BL1__A_63 BL0__A_63 BL0_B_0 BL1_B_0
+  BL2_B_0 BL3_B_0 BL3_B_1 BL2_B_1 BL1_B_1 BL0_B_1 BL0_B_2 BL1_B_2 BL2_B_2
+  BL3_B_2 BL3_B_3 BL2_B_3 BL1_B_3 BL0_B_3 BL0_B_4 BL1_B_4 BL2_B_4 BL3_B_4
+  BL3_B_5 BL2_B_5 BL1_B_5 BL0_B_5 BL0_B_6 BL1_B_6 BL2_B_6 BL3_B_6 BL3_B_7
+  BL2_B_7 BL1_B_7 BL0_B_7 BL0_B_8 BL1_B_8 BL2_B_8 BL3_B_8 BL3_B_9 BL2_B_9
+  BL1_B_9 BL0_B_9 BL0_B_10 BL1_B_10 BL2_B_10 BL3_B_10 BL3_B_11 BL2_B_11
+  BL1_B_11 BL0_B_11 BL0_B_12 BL1_B_12 BL2_B_12 BL3_B_12 BL3_B_13 BL2_B_13
+  BL1_B_13 BL0_B_13 BL0_B_14 BL1_B_14 BL2_B_14 BL3_B_14 BL3_B_15 BL2_B_15
+  BL1_B_15 BL0_B_15 BL0_B_16 BL1_B_16 BL2_B_16 BL3_B_16 BL3_B_17 BL2_B_17
+  BL1_B_17 BL0_B_17 BL0_B_18 BL1_B_18 BL2_B_18 BL3_B_18 BL3_B_19 BL2_B_19
+  BL1_B_19 BL0_B_19 BL0_B_20 BL1_B_20 BL2_B_20 BL3_B_20 BL3_B_21 BL2_B_21
+  BL1_B_21 BL0_B_21 BL0_B_22 BL1_B_22 BL2_B_22 BL3_B_22 BL3_B_23 BL2_B_23
+  BL1_B_23 BL0_B_23 BL0_B_24 BL1_B_24 BL2_B_24 BL3_B_24 BL3_B_25 BL2_B_25
+  BL1_B_25 BL0_B_25 BL0_B_26 BL1_B_26 BL2_B_26 BL3_B_26 BL3_B_27 BL2_B_27
+  BL1_B_27 BL0_B_27 BL0_B_28 BL1_B_28 BL2_B_28 BL3_B_28 BL3_B_29 BL2_B_29
+  BL1_B_29 BL0_B_29 BL0_B_30 BL1_B_30 BL2_B_30 BL3_B_30 BL3_B_31 BL2_B_31
+  BL1_B_31 BL0_B_31 BL0_B_32 BL1_B_32 BL2_B_32 BL3_B_32 BL3_B_33 BL2_B_33
+  BL1_B_33 BL0_B_33 BL0_B_34 BL1_B_34 BL2_B_34 BL3_B_34 BL3_B_35 BL2_B_35
+  BL1_B_35 BL0_B_35 BL0_B_36 BL1_B_36 BL2_B_36 BL3_B_36 BL3_B_37 BL2_B_37
+  BL1_B_37 BL0_B_37 BL0_B_38 BL1_B_38 BL2_B_38 BL3_B_38 BL3_B_39 BL2_B_39
+  BL1_B_39 BL0_B_39 BL0_B_40 BL1_B_40 BL2_B_40 BL3_B_40 BL3_B_41 BL2_B_41
+  BL1_B_41 BL0_B_41 BL0_B_42 BL1_B_42 BL2_B_42 BL3_B_42 BL3_B_43 BL2_B_43
+  BL1_B_43 BL0_B_43 BL0_B_44 BL1_B_44 BL2_B_44 BL3_B_44 BL3_B_45 BL2_B_45
+  BL1_B_45 BL0_B_45 BL0_B_46 BL1_B_46 BL2_B_46 BL3_B_46 BL3_B_47 BL2_B_47
+  BL1_B_47 BL0_B_47 BL0_B_48 BL1_B_48 BL2_B_48 BL3_B_48 BL3_B_49 BL2_B_49
+  BL1_B_49 BL0_B_49 BL0_B_50 BL1_B_50 BL2_B_50 BL3_B_50 BL3_B_51 BL2_B_51
+  BL1_B_51 BL0_B_51 BL0_B_52 BL1_B_52 BL2_B_52 BL3_B_52 BL3_B_53 BL2_B_53
+  BL1_B_53 BL0_B_53 BL0_B_54 BL1_B_54 BL2_B_54 BL3_B_54 BL3_B_55 BL2_B_55
+  BL1_B_55 BL0_B_55 BL0_B_56 BL1_B_56 BL2_B_56 BL3_B_56 BL3_B_57 BL2_B_57
+  BL1_B_57 BL0_B_57 BL0_B_58 BL1_B_58 BL2_B_58 BL3_B_58 BL3_B_59 BL2_B_59
+  BL1_B_59 BL0_B_59 BL0_B_60 BL1_B_60 BL2_B_60 BL3_B_60 BL3_B_61 BL2_B_61
+  BL1_B_61 BL0_B_61 BL0_B_62 BL1_B_62 BL2_B_62 BL3_B_62 BL3_B_63 BL2_B_63
+  BL1_B_63 BL0_B_63 BL0__B_0 BL1__B_0 BL2__B_0 BL3__B_0 BL3__B_1 BL2__B_1
+  BL1__B_1 BL0__B_1 BL0__B_2 BL1__B_2 BL2__B_2 BL3__B_2 BL3__B_3 BL2__B_3
+  BL1__B_3 BL0__B_3 BL0__B_4 BL1__B_4 BL2__B_4 BL3__B_4 BL3__B_5 BL2__B_5
+  BL1__B_5 BL0__B_5 BL0__B_6 BL1__B_6 BL2__B_6 BL3__B_6 BL3__B_7 BL2__B_7
+  BL1__B_7 BL0__B_7 BL0__B_8 BL1__B_8 BL2__B_8 BL3__B_8 BL3__B_9 BL2__B_9
+  BL1__B_9 BL0__B_9 BL0__B_10 BL1__B_10 BL2__B_10 BL3__B_10 BL3__B_11
+  BL2__B_11 BL1__B_11 BL0__B_11 BL0__B_12 BL1__B_12 BL2__B_12 BL3__B_12
+  BL3__B_13 BL2__B_13 BL1__B_13 BL0__B_13 BL0__B_14 BL1__B_14 BL2__B_14
+  BL3__B_14 BL3__B_15 BL2__B_15 BL1__B_15 BL0__B_15 BL0__B_16 BL1__B_16
+  BL2__B_16 BL3__B_16 BL3__B_17 BL2__B_17 BL1__B_17 BL0__B_17 BL0__B_18
+  BL1__B_18 BL2__B_18 BL3__B_18 BL3__B_19 BL2__B_19 BL1__B_19 BL0__B_19
+  BL0__B_20 BL1__B_20 BL2__B_20 BL3__B_20 BL3__B_21 BL2__B_21 BL1__B_21
+  BL0__B_21 BL0__B_22 BL1__B_22 BL2__B_22 BL3__B_22 BL3__B_23 BL2__B_23
+  BL1__B_23 BL0__B_23 BL0__B_24 BL1__B_24 BL2__B_24 BL3__B_24 BL3__B_25
+  BL2__B_25 BL1__B_25 BL0__B_25 BL0__B_26 BL1__B_26 BL2__B_26 BL3__B_26
+  BL3__B_27 BL2__B_27 BL1__B_27 BL0__B_27 BL0__B_28 BL1__B_28 BL2__B_28
+  BL3__B_28 BL3__B_29 BL2__B_29 BL1__B_29 BL0__B_29 BL0__B_30 BL1__B_30
+  BL2__B_30 BL3__B_30 BL3__B_31 BL2__B_31 BL1__B_31 BL0__B_31 BL0__B_32
+  BL1__B_32 BL2__B_32 BL3__B_32 BL3__B_33 BL2__B_33 BL1__B_33 BL0__B_33
+  BL0__B_34 BL1__B_34 BL2__B_34 BL3__B_34 BL3__B_35 BL2__B_35 BL1__B_35
+  BL0__B_35 BL0__B_36 BL1__B_36 BL2__B_36 BL3__B_36 BL3__B_37 BL2__B_37
+  BL1__B_37 BL0__B_37 BL0__B_38 BL1__B_38 BL2__B_38 BL3__B_38 BL3__B_39
+  BL2__B_39 BL1__B_39 BL0__B_39 BL0__B_40 BL1__B_40 BL2__B_40 BL3__B_40
+  BL3__B_41 BL2__B_41 BL1__B_41 BL0__B_41 BL0__B_42 BL1__B_42 BL2__B_42
+  BL3__B_42 BL3__B_43 BL2__B_43 BL1__B_43 BL0__B_43 BL0__B_44 BL1__B_44
+  BL2__B_44 BL3__B_44 BL3__B_45 BL2__B_45 BL1__B_45 BL0__B_45 BL0__B_46
+  BL1__B_46 BL2__B_46 BL3__B_46 BL3__B_47 BL2__B_47 BL1__B_47 BL0__B_47
+  BL0__B_48 BL1__B_48 BL2__B_48 BL3__B_48 BL3__B_49 BL2__B_49 BL1__B_49
+  BL0__B_49 BL0__B_50 BL1__B_50 BL2__B_50 BL3__B_50 BL3__B_51 BL2__B_51
+  BL1__B_51 BL0__B_51 BL0__B_52 BL1__B_52 BL2__B_52 BL3__B_52 BL3__B_53
+  BL2__B_53 BL1__B_53 BL0__B_53 BL0__B_54 BL1__B_54 BL2__B_54 BL3__B_54
+  BL3__B_55 BL2__B_55 BL1__B_55 BL0__B_55 BL0__B_56 BL1__B_56 BL2__B_56
+  BL3__B_56 BL3__B_57 BL2__B_57 BL1__B_57 BL0__B_57 BL0__B_58 BL1__B_58
+  BL2__B_58 BL3__B_58 BL3__B_59 BL2__B_59 BL1__B_59 BL0__B_59 BL0__B_60
+  BL1__B_60 BL2__B_60 BL3__B_60 BL3__B_61 BL2__B_61 BL1__B_61 BL0__B_61
+  BL0__B_62 BL1__B_62 BL2__B_62 BL3__B_62 BL3__B_63 BL2__B_63 BL1__B_63
+  BL0__B_63 VSSE VSSE VSSE VSSE VSSE VSSE BTPWDT_0 BTPWDT_1 VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE MBL_0_1060 MBL_1_1058 VSSE VSSE VSSE VSSE
+  VSSE VSSE MGTPST_0 MGTPST_1 VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE
+  VDDCE VDDPE VDDPE VDDCE VDDCE VDDPE VDDPE VDDCE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  RBTP_0 RBTP_1 RBTPT_0 RBTPT_1 RDTN_0 RDTN_1 RET_0 RET_1 RET_0 RET_1 RRA0_0
+  RRA0_1 RRA0__0 RRA0__1 RRA1_0 RRA1_1 RRA1__0 RRA1__1 VSSE VSSE TIEHI TIELO
+  XP0_0 XP0_1 XP1_0 XP1_1 XP2_0 XP2_1 XP3_0 XP3_1 XP4_0 XP4_1 XP5_0 XP5_1
+  XP6_0 XP6_1 XP7_0 XP7_1 XP8_0 XP8_1 XP9_0 XP9_1 XP10_0 XP10_1 XP11_0 XP11_1
+  XP12_0 XP12_1 XP13_0 XP13_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpBANK_ARRAY_0
.ENDS pe_spad_1024x16_dpFULL_1BANK
****
.SUBCKT pe_spad_1024x16_dp QA[15] QA[14] QA[13] QA[12] QA[11] QA[10] QA[9]
+  QA[8] QA[7] QA[6] QA[5] QA[4] QA[3] QA[2] QA[1] QA[0] QB[15] QB[14] QB[13]
+  QB[12] QB[11] QB[10] QB[9] QB[8] QB[7] QB[6] QB[5] QB[4] QB[3] QB[2] QB[1]
+  QB[0] CLKA CENA WENA AA[9] AA[8] AA[7] AA[6] AA[5] AA[4] AA[3] AA[2] AA[1]
+  AA[0] DA[15] DA[14] DA[13] DA[12] DA[11] DA[10] DA[9] DA[8] DA[7] DA[6]
+  DA[5] DA[4] DA[3] DA[2] DA[1] DA[0] CLKB CENB WENB AB[9] AB[8] AB[7] AB[6]
+  AB[5] AB[4] AB[3] AB[2] AB[1] AB[0] DB[15] DB[14] DB[13] DB[12] DB[11]
+  DB[10] DB[9] DB[8] DB[7] DB[6] DB[5] DB[4] DB[3] DB[2] DB[1] DB[0] EMAA[2]
+  EMAA[1] EMAA[0] EMAB[2] EMAB[1] EMAB[0] RETN VDDPE VDDCE VSSE
** pe_spad_1024x16_dp: 167598 flat devices **
XI0_0 AI0N_0 AI0N_1 AA[0] AB[0] AI1N_0 AI1N_1 AA[1] AB[1] AI2N_0 AI2N_1 AA[2]
+  AB[2] AI3N_0 AI3N_1 AA[3] AB[3] AI4N_0 AI4N_1 AA[4] AB[4] AI5N_0 AI5N_1
+  AA[5] AB[5] AI6N_0 AI6N_1 AA[6] AB[6] AI7N_0 AI7N_1 AA[7] AB[7] AI8N_0
+  AI8N_1 AA[8] AB[8] AI9N_0 AI9N_1 AA[9] AB[9] AI10N_0 AI10N_1 AI11N_0
+  AI11N_1 AI12N_0 AI12N_1 AO4_0 AO4_1 AO5_0 AO5_1 AO6_0 AO6_1 AO7_0 AO7_1
+  AO8_0 AO8_1 AO9_0 AO9_1 AO10_0 AO10_1 AO11_0 AO11_1 AO12_0 AO12_1 BWEA_0
+  BWEA_1 BWEA_2 BWEA_3 BWEA_4 BWEA_5 BWEA_6 BWEA_7 BWEA_8 BWEA_9 BWEA_10
+  BWEA_11 BWEA_12 BWEA_13 BWEA_14 BWEA_15 BWEB_0 BWEB_1 BWEB_2 BWEB_3 BWEB_4
+  BWEB_5 BWEB_6 BWEB_7 BWEB_8 BWEB_9 BWEB_10 BWEB_11 BWEB_12 BWEB_13 BWEB_14
+  BWEB_15 CEI_0 CEI_1 CENA CENB CLKA CLKB TIEHI DA[0] DA[1] DA[2] DA[3] DA[4]
+  DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14] DA[15]
+  DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11]
+  DB[12] DB[13] DB[14] DB[15] DNA_0 DNA_1 DNA_2 DNA_3 DNA_4 DNA_5 DNA_6 DNA_7
+  DNA_8 DNA_9 DNA_10 DNA_11 DNA_12 DNA_13 DNA_14 DNA_15 DNB_0 DNB_1 DNB_2
+  DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 DNB_8 DNB_9 DNB_10 DNB_11 DNB_12 DNB_13
+  DNB_14 DNB_15 EMAA[0] EMAB[0] EMAA[1] EMAB[1] EMAA[2] EMAB[2] GWEI_0 GWEI_1
+  WENA WENB TERM_IRET_0 TERM_IRET_0 TERM_IRET_0 TERM_IRET_0 TERM_IRET_0
+  TERM_IRET_0 TERM_IRET_0 TERM_IRET_0 IRET_15 IRET_15 IRET_15 IRET_15 IRET_15
+  IRET_15 IRET_15 IRET_15 QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7]
+  QA[8] QA[9] QA[10] QA[11] QA[12] QA[13] QA[14] QA[15] QA__0 QA__1 QA__2
+  QA__3 QA__4 QA__5 QA__6 QA__7 QA__8 QA__9 QA__10 QA__11 QA__12 QA__13
+  QA__14 QA__15 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+  QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB__0 QB__1 QB__2 QB__3 QB__4
+  QB__5 QB__6 QB__7 QB__8 QB__9 QB__10 QB__11 QB__12 QB__13 QB__14 QB__15
+  RETN RET_1 RET_1 TERM_IRET_0 IRET_15 TERM_ORET_8 TERM_ORET_8 TERM_ORET_8
+  TERM_ORET_8 TERM_ORET_8 TERM_ORET_8 TERM_ORET_8 TERM_ORET_8 TERM_ORET_8
+  TERM_ORET_17 TERM_ORET_17 TERM_ORET_17 TERM_ORET_17 TERM_ORET_17
+  TERM_ORET_17 TERM_ORET_17 TERM_ORET_17 TERM_ORET_17 TIEHI TIELO VDDPE VDDCE
+  VSSE pe_spad_1024x16_dpBOT_ROW
XI0_1 AI0N_0 AI0N_1 AI1N_0 AI1N_1 AI2N_0 AI2N_1 AI3N_0 AI3N_1 AI4N_0 AI4N_1
+  AI5N_0 AI5N_1 AI6N_0 AI6N_1 AI7N_0 AI7N_1 AI8N_0 AI8N_1 AI9N_0 AI9N_1
+  AI10N_0 AI10N_1 AI11N_0 AI11N_1 AI12N_0 AI12N_1 AO4_0 AO4_1 AO5_0 AO5_1
+  AO6_0 AO6_1 AO7_0 AO7_1 AO8_0 AO8_1 AO9_0 AO9_1 AO10_0 AO10_1 AO11_0 AO11_1
+  AO12_0 AO12_1 AX0N_0 AX0N_1 AX1N_0 AX1N_1 AX2N_0 AX2N_1 AX3N_0 AX3N_1
+  AX4N_0 AX4N_1 AX5N_0 AX5N_1 AY0N_0 AY0N_1 AY1N_0 AY1N_1 BS0N_0 BS0N_1
+  BS1N_0 BS1N_1 BS2N_0 BS2N_1 BWEA_0 BWEA_1 BWEA_2 BWEA_3 BWEA_4 BWEA_5
+  BWEA_6 BWEA_7 BWEA_8 BWEA_9 BWEA_10 BWEA_11 BWEA_12 BWEA_13 BWEA_14 BWEA_15
+  BWEB_0 BWEB_1 BWEB_2 BWEB_3 BWEB_4 BWEB_5 BWEB_6 BWEB_7 BWEB_8 BWEB_9
+  BWEB_10 BWEB_11 BWEB_12 BWEB_13 BWEB_14 BWEB_15 CEI_0 CEI_1 CLKA CLKB DNA_0
+  DNA_1 DNA_2 DNA_3 DNA_4 DNA_5 DNA_6 DNA_7 DNA_8 DNA_9 DNA_10 DNA_11 DNA_12
+  DNA_13 DNA_14 DNA_15 DNB_0 DNB_1 DNB_2 DNB_3 DNB_4 DNB_5 DNB_6 DNB_7 DNB_8
+  DNB_9 DNB_10 DNB_11 DNB_12 DNB_13 DNB_14 DNB_15 EMAA[0] EMAB[0] EMAA[1]
+  EMAB[1] EMAA[2] EMAB[2] GDLA_0 GDLA_1 GDLA_2 GDLA_3 GDLA_4 GDLA_5 GDLA_6
+  GDLA_7 GDLA_8 GDLA_9 GDLA_10 GDLA_11 GDLA_12 GDLA_13 GDLA_14 GDLA_15
+  GDLA_16 GDLA_17 GDLA_18 GDLA_19 GDLA_20 GDLA_21 GDLA_22 GDLA_23 GDLA_24
+  GDLA_25 GDLA_26 GDLA_27 GDLA_28 GDLA_29 GDLA_30 GDLA_31 GDLA_32 GDLA_33
+  GDLA_34 GDLA_35 GDLA_36 GDLA_37 GDLA_38 GDLA_39 GDLA_40 GDLA_41 GDLA_42
+  GDLA_43 GDLA_44 GDLA_45 GDLA_46 GDLA_47 GDLA_48 GDLA_49 GDLA_50 GDLA_51
+  GDLA_52 GDLA_53 GDLA_54 GDLA_55 GDLA_56 GDLA_57 GDLA_58 GDLA_59 GDLA_60
+  GDLA_61 GDLA_62 GDLA_63 GDLA__0 GDLA__1 GDLA__2 GDLA__3 GDLA__4 GDLA__5
+  GDLA__6 GDLA__7 GDLA__8 GDLA__9 GDLA__10 GDLA__11 GDLA__12 GDLA__13
+  GDLA__14 GDLA__15 GDLA__16 GDLA__17 GDLA__18 GDLA__19 GDLA__20 GDLA__21
+  GDLA__22 GDLA__23 GDLA__24 GDLA__25 GDLA__26 GDLA__27 GDLA__28 GDLA__29
+  GDLA__30 GDLA__31 GDLA__32 GDLA__33 GDLA__34 GDLA__35 GDLA__36 GDLA__37
+  GDLA__38 GDLA__39 GDLA__40 GDLA__41 GDLA__42 GDLA__43 GDLA__44 GDLA__45
+  GDLA__46 GDLA__47 GDLA__48 GDLA__49 GDLA__50 GDLA__51 GDLA__52 GDLA__53
+  GDLA__54 GDLA__55 GDLA__56 GDLA__57 GDLA__58 GDLA__59 GDLA__60 GDLA__61
+  GDLA__62 GDLA__63 GDLB_0 GDLB_1 GDLB_2 GDLB_3 GDLB_4 GDLB_5 GDLB_6 GDLB_7
+  GDLB_8 GDLB_9 GDLB_10 GDLB_11 GDLB_12 GDLB_13 GDLB_14 GDLB_15 GDLB_16
+  GDLB_17 GDLB_18 GDLB_19 GDLB_20 GDLB_21 GDLB_22 GDLB_23 GDLB_24 GDLB_25
+  GDLB_26 GDLB_27 GDLB_28 GDLB_29 GDLB_30 GDLB_31 GDLB_32 GDLB_33 GDLB_34
+  GDLB_35 GDLB_36 GDLB_37 GDLB_38 GDLB_39 GDLB_40 GDLB_41 GDLB_42 GDLB_43
+  GDLB_44 GDLB_45 GDLB_46 GDLB_47 GDLB_48 GDLB_49 GDLB_50 GDLB_51 GDLB_52
+  GDLB_53 GDLB_54 GDLB_55 GDLB_56 GDLB_57 GDLB_58 GDLB_59 GDLB_60 GDLB_61
+  GDLB_62 GDLB_63 GDLB__0 GDLB__1 GDLB__2 GDLB__3 GDLB__4 GDLB__5 GDLB__6
+  GDLB__7 GDLB__8 GDLB__9 GDLB__10 GDLB__11 GDLB__12 GDLB__13 GDLB__14
+  GDLB__15 GDLB__16 GDLB__17 GDLB__18 GDLB__19 GDLB__20 GDLB__21 GDLB__22
+  GDLB__23 GDLB__24 GDLB__25 GDLB__26 GDLB__27 GDLB__28 GDLB__29 GDLB__30
+  GDLB__31 GDLB__32 GDLB__33 GDLB__34 GDLB__35 GDLB__36 GDLB__37 GDLB__38
+  GDLB__39 GDLB__40 GDLB__41 GDLB__42 GDLB__43 GDLB__44 GDLB__45 GDLB__46
+  GDLB__47 GDLB__48 GDLB__49 GDLB__50 GDLB__51 GDLB__52 GDLB__53 GDLB__54
+  GDLB__55 GDLB__56 GDLB__57 GDLB__58 GDLB__59 GDLB__60 GDLB__61 GDLB__62
+  GDLB__63 GTPDE_0 GTPDS_1 GTPDE_0 GTPDS_1 GTP_0 GTP_1 GWEI_0 GWEI_1
+  TERM_IRET_0 IRET_15 LGWE_0 LGWE_1 MBL_0 MBL_1 MGDLE_0 MGDLS_1 MGDLE_0
+  MGDLS_1 MGTPS_0 MGTPS_1 TERM_ORET_8 TERM_ORET_17 TIELO TIELO TIELO TIELO
+  TIELO TIELO TIELO TIELO QA__0 QA__1 QA__2 QA__3 QA__4 QA__5 QA__6 QA__7
+  QA__8 QA__9 QA__10 QA__11 QA__12 QA__13 QA__14 QA__15 QB__0 QB__1 QB__2
+  QB__3 QB__4 QB__5 QB__6 QB__7 QB__8 QB__9 QB__10 QB__11 QB__12 QB__13
+  QB__14 QB__15 RDTN_0 RDTN_1 RET_1 RRA0_0 RRA0_1 RRA0__0 RRA0__1 RRA1_0
+  RRA1_1 RRA1__0 RRA1__1 TIEHI TIEHI TIELO TIELO VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE
+  VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE VSSE TIEHI
+  TIEHI TIELO TIELO WBT_0 WBT_1 VDDPE VDDCE VSSE pe_spad_1024x16_dpGCTRL_ROW
XI0_2 AX0N_0 AX0N_1 AX1N_0 AX1N_1 AX2N_0 AX2N_1 AX3N_0 AX3N_1 AX4N_0 AX4N_1
+  AX5N_0 AX5N_1 AY0N_0 AY0N_1 AY1N_0 AY1N_1 BS0N_0 BS0N_1 BS1N_0 BS1N_1
+  BS2N_0 BS2N_1 GDLA_0 GDLB_0 GDLB_1 GDLA_1 GDLA_2 GDLB_2 GDLB_3 GDLA_3
+  GDLA_4 GDLB_4 GDLB_5 GDLA_5 GDLA_6 GDLB_6 GDLB_7 GDLA_7 GDLA_8 GDLB_8
+  GDLB_9 GDLA_9 GDLA_10 GDLB_10 GDLB_11 GDLA_11 GDLA_12 GDLB_12 GDLB_13
+  GDLA_13 GDLA_14 GDLB_14 GDLB_15 GDLA_15 GDLA_16 GDLB_16 GDLB_17 GDLA_17
+  GDLA_18 GDLB_18 GDLB_19 GDLA_19 GDLA_20 GDLB_20 GDLB_21 GDLA_21 GDLA_22
+  GDLB_22 GDLB_23 GDLA_23 GDLA_24 GDLB_24 GDLB_25 GDLA_25 GDLA_26 GDLB_26
+  GDLB_27 GDLA_27 GDLA_28 GDLB_28 GDLB_29 GDLA_29 GDLA_30 GDLB_30 GDLB_31
+  GDLA_31 GDLA_32 GDLB_32 GDLB_33 GDLA_33 GDLA_34 GDLB_34 GDLB_35 GDLA_35
+  GDLA_36 GDLB_36 GDLB_37 GDLA_37 GDLA_38 GDLB_38 GDLB_39 GDLA_39 GDLA_40
+  GDLB_40 GDLB_41 GDLA_41 GDLA_42 GDLB_42 GDLB_43 GDLA_43 GDLA_44 GDLB_44
+  GDLB_45 GDLA_45 GDLA_46 GDLB_46 GDLB_47 GDLA_47 GDLA_48 GDLB_48 GDLB_49
+  GDLA_49 GDLA_50 GDLB_50 GDLB_51 GDLA_51 GDLA_52 GDLB_52 GDLB_53 GDLA_53
+  GDLA_54 GDLB_54 GDLB_55 GDLA_55 GDLA_56 GDLB_56 GDLB_57 GDLA_57 GDLA_58
+  GDLB_58 GDLB_59 GDLA_59 GDLA_60 GDLB_60 GDLB_61 GDLA_61 GDLA_62 GDLB_62
+  GDLB_63 GDLA_63 GDLA__0 GDLB__0 GDLB__1 GDLA__1 GDLA__2 GDLB__2 GDLB__3
+  GDLA__3 GDLA__4 GDLB__4 GDLB__5 GDLA__5 GDLA__6 GDLB__6 GDLB__7 GDLA__7
+  GDLA__8 GDLB__8 GDLB__9 GDLA__9 GDLA__10 GDLB__10 GDLB__11 GDLA__11
+  GDLA__12 GDLB__12 GDLB__13 GDLA__13 GDLA__14 GDLB__14 GDLB__15 GDLA__15
+  GDLA__16 GDLB__16 GDLB__17 GDLA__17 GDLA__18 GDLB__18 GDLB__19 GDLA__19
+  GDLA__20 GDLB__20 GDLB__21 GDLA__21 GDLA__22 GDLB__22 GDLB__23 GDLA__23
+  GDLA__24 GDLB__24 GDLB__25 GDLA__25 GDLA__26 GDLB__26 GDLB__27 GDLA__27
+  GDLA__28 GDLB__28 GDLB__29 GDLA__29 GDLA__30 GDLB__30 GDLB__31 GDLA__31
+  GDLA__32 GDLB__32 GDLB__33 GDLA__33 GDLA__34 GDLB__34 GDLB__35 GDLA__35
+  GDLA__36 GDLB__36 GDLB__37 GDLA__37 GDLA__38 GDLB__38 GDLB__39 GDLA__39
+  GDLA__40 GDLB__40 GDLB__41 GDLA__41 GDLA__42 GDLB__42 GDLB__43 GDLA__43
+  GDLA__44 GDLB__44 GDLB__45 GDLA__45 GDLA__46 GDLB__46 GDLB__47 GDLA__47
+  GDLA__48 GDLB__48 GDLB__49 GDLA__49 GDLA__50 GDLB__50 GDLB__51 GDLA__51
+  GDLA__52 GDLB__52 GDLB__53 GDLA__53 GDLA__54 GDLB__54 GDLB__55 GDLA__55
+  GDLA__56 GDLB__56 GDLB__57 GDLA__57 GDLA__58 GDLB__58 GDLB__59 GDLA__59
+  GDLA__60 GDLB__60 GDLB__61 GDLA__61 GDLA__62 GDLB__62 GDLB__63 GDLA__63
+  GTPDE_0 GTPDS_1 GTP_0 GTP_1 LGWE_0 LGWE_1 MBL_0 MBL_1 MGDLE_0 MGDLS_1
+  MGTPS_0 MGTPS_1 RDTN_0 RDTN_1 RET_1 RET_1 RRA0_0 RRA0_1 RRA0__0 RRA0__1
+  RRA1_0 RRA1_1 RRA1__0 RRA1__1 TIEHI TIEHI TIEHI TIELO WBT_0 WBT_1 VDDPE
+  VDDCE VSSE pe_spad_1024x16_dpFULL_1BANK
.ENDS pe_spad_1024x16_dp
